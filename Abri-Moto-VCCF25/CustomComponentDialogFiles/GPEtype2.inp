page("TeklaStructures","")
{
   joint(1, "GPEtype2")
   {
       tab_page("", " Paramètres 1 ", 1)
       {
       }
   }
}