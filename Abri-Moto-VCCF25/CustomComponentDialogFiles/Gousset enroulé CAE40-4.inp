page("TeklaStructures","")
{
   joint(1, "Gousset enroulé CAE40-4")
   {
       tab_page("", " Paramètres 1 ", 1)
       {
       }
   }
}