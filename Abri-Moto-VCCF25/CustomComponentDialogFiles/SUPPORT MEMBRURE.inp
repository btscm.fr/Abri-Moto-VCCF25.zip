page("TeklaStructures","")
{
   joint(1, "SUPPORT MEMBRURE")
   {
       tab_page("", " Paramètres 1 ", 1)
       {
       }
   }
}