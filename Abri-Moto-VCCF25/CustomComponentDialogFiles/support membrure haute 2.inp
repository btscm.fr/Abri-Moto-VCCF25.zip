page("TeklaStructures","")
{
   joint(1, "support membrure haute 2")
   {
       tab_page("", " Paramètres 1 ", 1)
       {
       }
   }
}