page("TeklaStructures","")
{
   joint(1, "GPEtype1")
   {
       tab_page("", " Paramètres 1 ", 1)
       {
       }
   }
}