Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:Off], Option [Assemblies:On], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:Off], Option [LocationBy:0], Option [ViewColors:On], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: IFC.ifc
Time: 2023-04-10T23:30:46
Author: PORTCM01\professeur
Organization: Structural Designer
Written by: IFC Database Version: Work
Made in: Tekla Structures Educational 2021 Service Pack 6, IFC Export Version: 4.0.0.0 Dec 9 2021

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: CC100-2-15-50 (6)
In: Undefined
Description: CC100-2-15-50; Material: STEEL/S235JR
Tekla Commun - Phase: 1; Classe: 9; Matériau: S235JR; Profil: CC100-2-15-50; Nom: C_JORIS100
Tekla Quantités - Poids: 8.4 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 128.6 m2; Surface nette: 1.1 m2; Hauteur: 100 mm; Largeur: 50 mm
Pset_BeamCommon - LoadBearing: no
Name | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
C_JORIS100 | +2.321 | +2.428 | A31 | 2403.5 | 2403.5 | 1.07766 | 0.00106715 | 8.37716
C_JORIS100 | +2.087 | +2.195 | A22 | 2401.2 | 2401.15 | 1.0766 | 0.00106611 | 8.36898
C_JORIS100 | +2.321 | +2.428 | A13 | 2403.5 | 2403.5 | 1.07766 | 0.00106715 | 8.37716
C_JORIS100 | +2.554 | +2.661 | A26 | 2403.5 | 2403.5 | 1.07766 | 0.00106716 | 8.37717
C_JORIS100 | +2.087 | +2.195 | A33 | 2407 | 2407 | 1.07922 | 0.00106871 | 8.38936
C_JORIS100 | +2.554 | +2.661 | A0(?) | 2393.5 | 2393.5 | 1.07318 | 0.00106271 | 8.3423

# IfcBeam: IPE140 (5)
In: Undefined
Description: IPE140; Material: STEEL/S235JR
Tekla Commun - Phase: 1; Matériau: S235JR; Profil: IPE140
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 42.8 m2; Largeur: 73 mm
Pset_BeamCommon - LoadBearing: no
Name | Niveau bas | Niveau haut | Repère de pièce = Reference | Repère d'assemblage | Finition | Classe | Nom | Poids (kg) | Surface nette (m2) | Hauteur (mm) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
ARBA | +2.030 | +2.686 | aa33(?) | A6(?) | GALVA | 4 | ARBA | 38.3 | 1.7 | 140 | 2978.8 | 2978.81 | 1.64133 | 0.00472811 | 37.1157
JARRET | +2.408 | +2.539 | 11 | A24 |  | 1 | JARRET | 3.9 | 0.1 | 123.5 | 300.1 | 300.146 | 0.16538 | 0.000405188 | 3.18073
JARRET | +2.408 | +2.539 | 1 | A20 |  | 1 | JARRET | 3.9 | 0.1 | 123.5 | 300.1 | 300.146 | 0.16538 | 0.000405188 | 3.18073
ARBA | +2.030 | +2.681 | aa14 | A24 | GALVA | 4 | ARBA | 38 | 1.6 | 140 | 2949.4 | 2949.36 | 1.6251 | 0.00468098 | 36.7457
ARBA | +2.030 | +2.681 | aa13 | A20 | GALVA | 4 | ARBA | 38 | 1.6 | 140 | 2949.4 | 2949.36 | 1.6251 | 0.00468098 | 36.7457

# IfcBeam: L45*4 (2)
In: Undefined
Description: L45*4; Material: STEEL/S235JR
Tekla Commun - Repère de pièce: 0; Repère d'assemblage: 0(?); Phase: 1; Classe: 5; Matériau: S235JR; Profil: L45*4; Nom: CORNIERE
Tekla Quantités - Poids: 0.4 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 63.5 m2; Surface nette: 0 m2; Hauteur: 45 mm; Largeur: 45 mm; Longueur: 170 mm
Pset_BeamCommon - LoadBearing: no; Reference: 0
BaseQuantities - Length: 170 mm; OuterSurfaceArea: 0.02958 m2; NetVolume: 0.00005848 m3; NetWeight: 0.459068 kg
Name | Niveau bas | Niveau haut
CORNIERE | +2.138 | +2.183
CORNIERE | +2.095 | +2.169

# IfcBeam: L60*4 (4)
In: Undefined
Description: L60*4; Material: STEEL/S235JR
Tekla Commun - Finition: GALVA; Phase: 1; Classe: 3; Matériau: S235JR; Profil: L60*4; Nom: CVT
Tekla Quantités - Poids: 9.1 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 64 m2; Surface nette: 0.6 m2; Hauteur: 60 mm; Largeur: 60 mm
Pset_BeamCommon - LoadBearing: no
Name | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
CVT | +2.081 | +2.355 | A40 | 2502.3 | 2502.28 | 0.583031 | 0.00116106 | 9.1143
CVT | +2.324 | +2.589 | A35 | 2497.7 | 2497.72 | 0.581969 | 0.00115894 | 9.09769
CVT | +2.324 | +2.589 | A38 | 2498.2 | 2498.24 | 0.58209 | 0.00115918 | 9.09958
CVT | +2.082 | +2.355 | A35 | 2498.2 | 2498.24 | 0.58209 | 0.00115918 | 9.09959

# IfcBeam: L60*60*6, CAI-Att-FA
In: Undefined
Description: L60*60*6; Material: STEEL/S235JR
Tekla Commun - Niveau bas: +2.586; Niveau haut: +2.661; Repère de pièce: A0(?); Repère d'assemblage: A0(?); Phase: 1; Classe: 3; Matériau: S235JR; Profil: L60*60*6; Nom: CAI-Att-FA
Tekla Quantités - Poids: 0.4 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 48.1 m2; Surface nette: 0 m2; Hauteur: 60 mm; Largeur: 60 mm; Longueur: 75 mm
Pset_BeamCommon - LoadBearing: no; Reference: A0(?)
BaseQuantities - Length: 75 mm; OuterSurfaceArea: 0.019368 m2; NetVolume: 0.0000513 m3; NetWeight: 0.402705 kg

# IfcBeam: L70*50*6, CAI-Att-FA
In: Undefined
Description: L70*50*6; Material: STEEL/S235JR
Pset_BeamCommon - LoadBearing: no; Reference: A0(?)
Tekla Commun - Niveau bas: +2.611; Niveau haut: +2.661; Repère de pièce: A0(?); Repère d'assemblage: A0(?); Phase: 1; Classe: 3; Matériau: S235JR; Profil: L70*50*6; Nom: CAI-Att-FA
Tekla Quantités - Poids: 0.4 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 43.5 m2; Surface nette: 0 m2; Hauteur: 70 mm; Largeur: 50 mm; Longueur: 50 mm
BaseQuantities - Length: 50 mm; OuterSurfaceArea: 0.01175 m2; NetVolume: 0.0000342 m3; NetWeight: 0.26847 kg

# IfcBeam: L70*70*6 (4)
In: Undefined
Description: L70*70*6; Material: STEEL/S235JR
Tekla Commun - Repère de pièce: A12; Repère d'assemblage: A12; Finition: GALVA; Phase: 1; Classe: 3; Matériau: S235JR; Profil: L70*70*6; Nom: ATTACHE MONTANT
Tekla Quantités - Poids: 0.4 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 49.5 m2; Surface nette: 0 m2; Hauteur: 70 mm; Largeur: 70 mm; Longueur: 50 mm
Pset_BeamCommon - LoadBearing: no; Reference: A12
BaseQuantities - Length: 50 mm; OuterSurfaceArea: 0.015608 m2; NetVolume: 0.0000402 m3; NetWeight: 0.31557 kg
Name | Niveau bas | Niveau haut
2 x ATTACHE MONTANT | +0.000 | +0.070
2 x ATTACHE MONTANT | +2.050 | +2.120

# IfcBeam: TC-C50*50*3.2 (4)
In: Undefined
Description: TC-C50*50*3.2; Material: STEEL/S235JR
Tekla Commun - Finition: GALVA; Classe: 13; Matériau: S235JR; Profil: TC-C50*50*3.2; Nom: TREILLIS
Tekla Quantités - Volume: 0 m3; Surface par tonne: 41.6 m2; Hauteur: 50 mm; Largeur: 50 mm
Pset_BeamCommon - LoadBearing: no
Name | Niveau bas | Niveau haut | Repère de pièce = Reference | Repère d'assemblage | Phase | Poids (kg) | Surface supérieure totale (m2) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
TREILLIS | +2.166 | +2.591 | aa24 | A14 | 7 | 5.8 | 0 | 0.2 | 1246.2 | 1246.21 | 0.239272 | 0.000705271 | 5.53637
TREILLIS | +2.170 | +2.591 | A15 | A15 | 7 | 5.7 | 0 | 0.2 | 1240.5 | 1240.46 | 0.238168 | 0.000698854 | 5.486
TREILLIS | +2.120 | +2.170 | aa9 | A14 | 7 | 22.6 | 0.2 | 1 | 4902.3 | 4902.32 | 0.941245 | 0.00292812 | 22.9857
TREILLIS | +2.611 | +2.661 | aa30(?) | A23(?) | 1 | 22.2 | 0.2 | 1 | 4805 | 4805.01 | 0.922562 | 0.00287391 | 22.5602

# IfcBeam: TUBE-C-50*50*3 (2)
In: Undefined
Description: TUBE-C-50*50*3; Material: STEEL/S235JR
Tekla Commun - Niveau bas: +2.075; Niveau haut: +2.125; Repère de pièce: aa20; Finition: GALVA; Phase: 1; Classe: 3; Matériau: S235JR; Profil: TUBE-C-50*50*3; Nom: CVT
Tekla Quantités - Poids: 9.8 kg; Volume: 0 m3; Surface supérieure totale: 0.1 m2; Surface par tonne: 44.5 m2; Surface nette: 0.5 m2; Hauteur: 50 mm; Largeur: 50 mm; Longueur: 2305 mm
Pset_BeamCommon - LoadBearing: no; Reference: aa20
BaseQuantities - Length: 2305 mm; OuterSurfaceArea: 0.435645 m2; NetVolume: 0.00129414 m3; NetWeight: 10.159 kg
Name | Repère d'assemblage
CVT | A2
CVT | A1

# IfcBeam: TUBE-R-70*40*3 (8)
In: Undefined
Description: TUBE-R-70*40*3; Material: STEEL/S235JR
Tekla Commun - Finition: GALVA; Phase: 1; Classe: 6; Matériau: S235JR; Profil: TUBE-R-70*40*3; Nom: LISSES
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0.2 m2; Surface par tonne: 42.9 m2; Hauteur: 70 mm; Largeur: 40 mm
Pset_BeamCommon - LoadBearing: no
Name | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Poids (kg) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
LISSES | +1.680 | +1.720 | A44 | 14 | 0.6 | 2874 | 2873.99 | 0.600665 | 0.00177316 | 13.9193
LISSES | +0.380 | +0.420 | A44 | 14 | 0.6 | 2874 | 2873.99 | 0.600665 | 0.00177316 | 13.9193
LISSES | +1.680 | +1.720 | A18 | 14 | 0.6 | 2874 | 2873.99 | 0.600665 | 0.00177316 | 13.9193
LISSES | +0.380 | +0.420 | A18 | 14 | 0.6 | 2874 | 2873.99 | 0.600665 | 0.00177316 | 13.9193
LISSES | +1.680 | +1.720 | A28 | 12.4 | 0.5 | 2537.5 | 2537.5 | 0.530338 | 0.00156319 | 12.271
LISSES | +0.380 | +0.420 | A28 | 12.4 | 0.5 | 2537.5 | 2537.5 | 0.530338 | 0.00156319 | 12.271
LISSES | +1.680 | +1.720 | A3 | 12.4 | 0.5 | 2537.5 | 2537.5 | 0.530338 | 0.00156319 | 12.271
LISSES | +0.380 | +0.420 | A3 | 12.4 | 0.5 | 2537.5 | 2537.5 | 0.530338 | 0.00156319 | 12.271

# IfcColumn: 250*250 (5)
In: Undefined
Description: 250*250; Material: CONCRETE/C25/30
Tekla Commun - Niveau bas: +0.000; Niveau haut: +0.200; Repère de pièce: Pt0(?); Repère d'assemblage: Pt0(?); Phase: 1; Classe: 13; Matériau: C25/30; Profil: 250*250; Nom: POTEAU
Tekla Quantités - Poids: 30 kg; Volume: 0 m3; Surface supérieure totale: 0.1 m2; Surface par tonne: 10.8 m2; Surface nette: 0.3 m2; Hauteur: 250 mm; Largeur: 250 mm; Longueur: 200 mm
Pset_ColumnCommon - LoadBearing: no; Reference: Pt0(?)
BaseQuantities - Length: 200 mm; OuterSurfaceArea: 0.325 m2; NetVolume: 0.0125 m3; NetWeight: 30 kg

# IfcColumn: D14 (10)
In: Undefined
Description: D14; Material: STEEL/S235JR
Tekla Commun - Niveau bas: +0.040; Niveau haut: +0.240; Repère de pièce: B0; Repère d'assemblage: B0(?); Phase: 1; Classe: 1; Matériau: S235JR; Profil: D14; Nom: BARRE
Tekla Quantités - Poids: 0.2 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 40.7 m2; Surface nette: 0 m2; Hauteur: 14 mm; Largeur: 14 mm; Longueur: 200 mm
Pset_ColumnCommon - LoadBearing: no; Reference: B0
BaseQuantities - Length: 200 mm; OuterSurfaceArea: 0.00884929 m2; NetVolume: 0.0000277186 m3; NetWeight: 0.217591 kg

# IfcColumn: HEA100 (5)
In: Undefined
Description: HEA100; Material: STEEL/S235JR
Tekla Commun - Niveau bas: +0.210; Finition: GALVA; Phase: 1; Classe: 4; Matériau: S235JR; Profil: HEA100
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 33.6 m2; Hauteur: 96 mm; Largeur: 100 mm
Pset_ColumnCommon - LoadBearing: no
Name | Niveau haut | Repère de pièce = Reference | Repère d'assemblage | Nom | Poids (kg) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
POTEAU AV | +2.162 | aa18(?) | A5(?) | POTEAU AV | 32.5 | 1.1 | 1951.7 | 1951.74 | 1.09493 | 0.00390348 | 30.6423
POTEAU AV | +2.675 | aa2 | A29 | POTEAU AV | 41.1 | 1.4 | 2464.9 | 2464.92 | 1.38282 | 0.00492984 | 38.6992
POTEAU AV | +2.162 | aa4 | A32 | POTEAU AV | 32.5 | 1.1 | 1951.7 | 1951.74 | 1.09493 | 0.00390348 | 30.6423
Poteau AR | +2.162 | aa1 | A7 | Poteau AR | 32.5 | 1.1 | 1951.7 | 1951.74 | 1.09493 | 0.00390348 | 30.6423
POTEAU AV | +2.675 | aa3 | A30 | POTEAU AV | 41.1 | 1.4 | 2464.9 | 2464.92 | 1.38282 | 0.00492984 | 38.6992

# IfcColumn: L60*60*6, CAI-Att-FA
In: Undefined
Description: L60*60*6; Material: STEEL/S235JR
Tekla Commun - Niveau bas: +2.586; Niveau haut: +2.661; Repère de pièce: A0(?); Repère d'assemblage: A0(?); Phase: 1; Classe: 3; Matériau: S235JR; Profil: L60*60*6; Nom: CAI-Att-FA
Tekla Quantités - Poids: 0.4 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 48.1 m2; Surface nette: 0 m2; Hauteur: 60 mm; Largeur: 60 mm; Longueur: 75 mm
BaseQuantities - Length: 75 mm; OuterSurfaceArea: 0.019368 m2; NetVolume: 0.0000513 m3; NetWeight: 0.402705 kg
Pset_ColumnCommon - LoadBearing: no; Reference: A0(?)

# IfcColumn: PD28*7 (10)
In: Undefined
Description: PD28*7; Material: STEEL/S235JR
Tekla Commun - Niveau bas: +0.216; Niveau haut: +0.230; Repère de pièce: E0; Repère d'assemblage: E0(?); Phase: 1; Classe: 1; Matériau: S235JR; Profil: PD28*7; Nom: ECROU
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 37.3 m2; Surface nette: 0 m2; Hauteur: 28 mm; Largeur: 28 mm; Longueur: 14 mm
Pset_ColumnCommon - LoadBearing: no; Reference: E0
BaseQuantities - Length: 14 mm; OuterSurfaceArea: 0.00180548 m2; NetVolume: 0.000006174 m3; NetWeight: 0.0484659 kg

# IfcColumn: TC-C50*50*3.2 (4)
In: Undefined
Description: TC-C50*50*3.2; Material: STEEL/S235JR
Tekla Commun - Finition: GALVA; Classe: 13; Matériau: S235JR; Profil: TC-C50*50*3.2; Nom: TREILLIS
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2
Pset_ColumnCommon - LoadBearing: no
Name | Niveau bas | Niveau haut | Repère de pièce = Reference | Repère d'assemblage | Phase | Poids (kg) | Surface par tonne (m2) | Surface nette (m2) | Hauteur (mm) = Largeur (mm) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x TREILLIS | +2.166 | +2.607 | aa11 | A14 | 7 | 2 | 41.6 | 0.1 | 50 | 441 | 441.007 | 0.0846733 | 0.000264177 | 2.07379
TREILLIS | +2.170 | +2.607 | A17 | A17 | 7 | 2 | 41.6 | 0.1 | 50 | 437.3 | 437.343 | 0.0839699 | 0.000261984 | 2.05657
TREILLIS |  |  | A25 | A25 | 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0

# IfcColumn: TR-F100*50*4 (3)
In: Undefined
Description: TR-F100*50*4; Material: STEEL/S235JR
Tekla Commun - Repère d'assemblage: P0(?); Phase: 1; Classe: 7; Matériau: S235JR; Profil: TR-F100*50*4; Nom: MONTANT
Tekla Quantités - Poids: 18.1 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 33.4 m2; Surface nette: 0.6 m2; Hauteur: 100 mm; Largeur: 50 mm
Pset_ColumnCommon - LoadBearing: no
Name | Niveau bas | Niveau haut | Repère de pièce = Reference | Longueur (mm) = Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
MONTANT | +10.000 | +12.114 | P0(?) | 2114 | 0.604604 | 0.00239415 | 18.7941
MONTANT | +0.000 | +2.114 | P0 | 2114 | 0.604604 | 0.00239415 | 18.7941
MONTANT | +0.000 | +2.120 | P0 | 2120 | 0.60632 | 0.00240097 | 18.8476

# IfcElementAssembly (114)
In: Undefined
Name | PredefinedType | Poids Assemblage/Elément béton (kg) | Niveau Bas Assemblage/Elément béton | Niveau Haut Assemblage/Elément béton | Position maillage Assemblage/Elément béton | Repère Assemblage/Elément béton | Width (mm)
2 x CAI-Att-FA | RIGID_FRAME | 0.4 | +2.586 | +2.661 | 2/A | A0(?) | 60
CAI-Att-FA | RIGID_FRAME | 0.4 | +2.611 | +2.661 | 2/A | A0(?) | 50
MONTANT | RIGID_FRAME | 18.1 | +10.000 | +12.114 | 3>/B> | P0(?) | 50
2 x ECROU | RIGID_FRAME | 0 | +0.216 | +0.230 | 3/B | E0(?) | 28
2 x Washer Plate | RIGID_FRAME | 0.1 | +0.210 | +0.216 | 3/B | E0(?) | 6
2 x BARRE | RIGID_FRAME | 0.2 | +0.040 | +0.240 | 3/B | B0(?) | 14
2 x ECROU | RIGID_FRAME | 0 | +0.216 | +0.230 | 3/A | E0(?) | 28
2 x Washer Plate | RIGID_FRAME | 0.1 | +0.210 | +0.216 | 3/A | E0(?) | 6
2 x BARRE | RIGID_FRAME | 0.2 | +0.040 | +0.240 | 3/A | B0(?) | 14
2 x ECROU | RIGID_FRAME | 0 | +0.216 | +0.230 | 2/B | E0(?) | 28
2 x Washer Plate | RIGID_FRAME | 0.1 | +0.210 | +0.216 | 2/B | E0(?) | 6
2 x BARRE | RIGID_FRAME | 0.2 | +0.040 | +0.240 | 2/B | B0(?) | 14
2 x ECROU | RIGID_FRAME | 0 | +0.216 | +0.230 | 1/B | E0(?) | 28
2 x Washer Plate | RIGID_FRAME | 0.1 | +0.210 | +0.216 | 1/B | E0(?) | 6
2 x BARRE | RIGID_FRAME | 0.2 | +0.040 | +0.240 | 1/B | B0(?) | 14
2 x ECROU | RIGID_FRAME | 0 | +0.216 | +0.230 | 1/A | E0(?) | 28
2 x Washer Plate | RIGID_FRAME | 0.1 | +0.210 | +0.216 | 1/A | E0(?) | 6
2 x BARRE | RIGID_FRAME | 0.2 | +0.040 | +0.240 | 1/A | B0(?) | 14
ATTACHE MONTANT | RIGID_FRAME | 0.4 | +0.000 | +0.070 | 2-3/A | A12 | 70
ATTACHE MONTANT | RIGID_FRAME | 0.4 | +0.000 | +0.070 | 1-2/A | A12 | 70
ATTACHE MONTANT | RIGID_FRAME | 0.4 | +2.050 | +2.120 | 2-3/A | A12 | 70
ATTACHE MONTANT | RIGID_FRAME | 0.4 | +2.050 | +2.120 | 1-2/A | A12 | 70
MONTANT | RIGID_FRAME | 18.1 | +0.000 | +2.114 | 2-3/A | P0(?) | 50
POTEAU | RIGID_FRAME | 18.1 | +0.000 | +2.120 | 1-2/A | P0(?) | 50
POTEAU | REINFORCEMENT_UNIT | 30 | +0.000 | +0.200 | 3/B | Pt0(?) | 250 | Tekla Assemblages - Cast unit type: Coulé sur site; Poids ferraillage Elément béton: 0 kg
POTEAU | REINFORCEMENT_UNIT | 30 | +0.000 | +0.200 | 2/B | Pt0(?) | 250 | Tekla Assemblages - Cast unit type: Coulé sur site; Poids ferraillage Elément béton: 0 kg
POTEAU | REINFORCEMENT_UNIT | 30 | +0.000 | +0.200 | 1/B | Pt0(?) | 250 | Tekla Assemblages - Cast unit type: Coulé sur site; Poids ferraillage Elément béton: 0 kg
POTEAU | REINFORCEMENT_UNIT | 30 | +0.000 | +0.200 | 1/A | Pt0(?) | 250 | Tekla Assemblages - Cast unit type: Coulé sur site; Poids ferraillage Elément béton: 0 kg
POTEAU | REINFORCEMENT_UNIT | 30 | +0.000 | +0.200 | 3/A | Pt0(?) | 250 | Tekla Assemblages - Cast unit type: Coulé sur site; Poids ferraillage Elément béton: 0 kg
POTEAU AV | RIGID_FRAME | 35.9 | +0.200 | +2.170 | 3/B | A5(?) | 172.775
CVT | RIGID_FRAME | 12.6 | +1.988 | +2.130 | 2-3/B | A1 | 142.004
CVT | RIGID_FRAME | 9.1 | +2.081 | +2.355 | 2-3/A-B | A40 | 60
CORNIERE | RIGID_FRAME | 0.4 | +2.095 | +2.169 | 3/B | 0(?) | 45
CORNIERE | RIGID_FRAME | 0.4 | +2.138 | +2.183 | 3/B | 0(?) | 45
TOLE | RIGID_FRAME | 2 | +2.131 | +2.175 | 3/B | E0(?) | 6
POTEAU AV | RIGID_FRAME | 44.1 | +0.200 | +2.683 | 3/A | A29 | 162.5
TREILLIS | RIGID_FRAME | 22.9 | +2.606 | +2.666 | 1-3/A | A23(?) | 50
POTEAU AV | RIGID_FRAME | 44.5 | +0.200 | +2.683 | 1/A | A30 | 162.5
POTEAU AV | RIGID_FRAME | 36.3 | +0.200 | +2.170 | 2/B | A32 | 195.275
ARBA | RIGID_FRAME | 47 | +1.868 | +2.686 | 2/A-B | A6(?) | 98
GOUSSET_ENROULE2 | RIGID_FRAME | 2.8 | +2.325 | +2.419 | 2/A-B | A11 | 102
GOUSSET_ENROULE2 | RIGID_FRAME | 2.8 | +2.278 | +2.418 | 2/A-B | A9 | 102
CVT | RIGID_FRAME | 9.1 | +2.324 | +2.589 | 2-3/A-B | A38 | 60
ARBA | RIGID_FRAME | 52.5 | +1.868 | +2.681 | 3/A-B | A24 | 98
CVT | RIGID_FRAME | 8.6 | +0.355 | +2.066 | 2-3/B | A45 | 50
CVT | RIGID_FRAME | 8.6 | +0.355 | +2.066 | 2-3/B | A4 | 50
C_JORIS100 | RIGID_FRAME | 8.4 | +2.554 | +2.661 | 1-2/A | A26 | 50
C_JORIS100 | RIGID_FRAME | 8.4 | +2.087 | +2.195 | 2-3/B | A22 | 50
C_JORIS100 | RIGID_FRAME | 8.4 | +2.554 | +2.661 | 2-3/A | A0(?) | 50
C_JORIS100 | RIGID_FRAME | 8.4 | +2.321 | +2.428 | 2-3/A-B | A13 | 50
C_JORIS100 | RIGID_FRAME | 8.4 | +2.321 | +2.428 | 1-2/A-B | A31 | 50
GOUSSET_ENROULE2 | RIGID_FRAME | 2.8 | +2.325 | +2.419 | 2/A-B | A41 | 102
GOUSSET_ENROULE2 | RIGID_FRAME | 2.8 | +2.278 | +2.418 | 2/A-B | A42 | 102
CVT | RIGID_FRAME | 9.1 | +2.324 | +2.589 | 1-2/A-B | A35 | 60
CVT | RIGID_FRAME | 9.1 | +2.082 | +2.355 | 1-2/A-B | A35 | 60
GOUSSET_ENROULE1 | RIGID_FRAME | 2.8 | +2.511 | +2.651 | 1/A | A19 | 102
GOUSSET_ENROULE4 | RIGID_FRAME | 2.8 | +2.512 | +2.651 | 3/A | A21 | 102
LISSES | RIGID_FRAME | 14 | +1.680 | +1.720 | 1/A-B | A44 | 40
LISSES | RIGID_FRAME | 14 | +0.380 | +0.420 | 1/A-B | A44 | 40
TREILLIS | RIGID_FRAME | 39.3 | +2.115 | +2.607 | 1-3/A | A14 | 145.001
TREILLIS | RIGID_FRAME | 5.7 | +2.170 | +2.591 | 1-2/A | A15 | 50
TREILLIS | RIGID_FRAME | 6 | +2.170 | +2.607 | 1-2/A | A16 | 50
TREILLIS | RIGID_FRAME | 2 | +2.170 | +2.607 | 1-2/A | A17 | 50
CVT | RIGID_FRAME | 1.5 | +2.216 | +2.463 | 2/A | A10 | 60
Support-Lisse | RIGID_FRAME | 0.6 | +0.310 | +0.380 | 1/B | A36 | 70
Support-Lisse | RIGID_FRAME | 0.6 | +1.610 | +1.680 | 1/B | A36 | 70
Support-Lisse | RIGID_FRAME | 0.6 | +0.310 | +0.380 | 1/A | A37 | 70
Support-Lisse | RIGID_FRAME | 0.6 | +1.610 | +1.680 | 1/A | A37 | 70
Support-Lisse | RIGID_FRAME | 0.6 | +0.310 | +0.380 | 3/A | A36 | 70
Support-Lisse | RIGID_FRAME | 0.6 | +1.610 | +1.680 | 3/A | A36 | 70
Support-Lisse | RIGID_FRAME | 0.6 | +0.310 | +0.380 | 3/B | A37 | 70
Support-Lisse | RIGID_FRAME | 0.6 | +1.610 | +1.680 | 3/B | A37 | 70
LISSES | RIGID_FRAME | 14 | +0.380 | +0.420 | 3/A-B | A18 | 40
LISSES | RIGID_FRAME | 14 | +1.680 | +1.720 | 3/A-B | A18 | 40
Support-Lisse | RIGID_FRAME | 0.6 | +0.310 | +0.380 | 3/B | A43 | 70
Support-Lisse | RIGID_FRAME | 0.6 | +1.610 | +1.680 | 3/B | A34 | 70
GOUSSET | RIGID_FRAME | 0.4 | +0.308 | +0.444 | 2/B | A27(?) | 6
GOUSSET | RIGID_FRAME | 0.4 | +0.308 | +0.444 | 3/B | A0(?) | 6
Poteau AR | RIGID_FRAME | 35.5 | +0.200 | +2.170 | 1/B | A7 | 162.5
CVT | RIGID_FRAME | 10.5 | +2.070 | +2.130 | 1-2/B | A2 | 60
C_JORIS100 | RIGID_FRAME | 8.4 | +2.087 | +2.195 | 1-2/B | A33 | 50
2 x GOUSSET | RIGID_FRAME | 0.6 | +2.085 | +2.181 | 2/B | A39 | 71
2 x GOUSSET | RIGID_FRAME | 0.6 | +2.551 | +2.648 | 2/A | A39 | 71
GOUSSET | RIGID_FRAME | 0.6 | +2.318 | +2.414 | 3/A-B | A39 | 71
ARBA | RIGID_FRAME | 52.5 | +1.868 | +2.681 | 1/A-B | A20 | 98
GOUSSET | RIGID_FRAME | 0.6 | +2.318 | +2.414 | 1/A-B | A39 | 71
TREILLIS | RIGID_FRAME | 0 |  |  |  | A25 | 0
LISSES | RIGID_FRAME | 12.4 | +0.380 | +0.420 | 2-3/B | A3 | 40
Support-Lisse | RIGID_FRAME | 0.6 | +0.310 | +0.380 | 2/B | 0(?) | 70
LISSES | RIGID_FRAME | 12.4 | +0.380 | +0.420 | 1-2/B | A28 | 40
Support-Lisse | RIGID_FRAME | 0.6 | +0.310 | +0.380 | 1/B | 0(?) | 70
LISSES | RIGID_FRAME | 12.4 | +1.680 | +1.720 | 1-2/B | A28 | 40
Support-Lisse | RIGID_FRAME | 0.6 | +1.610 | +1.680 | 1/B | 0(?) | 70
LISSES | RIGID_FRAME | 12.4 | +1.680 | +1.720 | 2-3/B | A3 | 40
Support-Lisse | RIGID_FRAME | 0.6 | +1.610 | +1.680 | 2/B | 0(?) | 70
GOUSSET_ENROULE2 | RIGID_FRAME | 2.8 | +2.092 | +2.186 | 1/B | A8 | 102

# IfcMechanicalFastener: Bolt assembly (116)
In: Undefined
Tekla Boulons - Trou oblong Y: 0 mm; Trou oblong X: 0 mm; Lieu Boulonnage: Montage
Name | NominalDiameter (mm) = Diamètre rondelle (mm) | NominalLength (mm) = Longueur (mm) | Material = Standard | Quantité de rondelle | Type rondelle | Nom rondelle | Quantité d'écrou | Type écrou | Nom écrou | Diamètre du trou (mm) | Quantité | Diamètre (mm) | Nom
3 x Bolt assembly | 12 | 35 | 8.8 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 2 | E-8.8 | ECROU-M12-E-8.8 | 14 | 2 | 12 | M12*35
Bolt assembly | 12 | 75 | 8.8 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 2 | E-8.8 | ECROU-M12-E-8.8 | 14 | 2 | 12 | M12*75
10 x Bolt assembly | 14 | 6 | 6.8 | 0 | PLA-6.8 | RONDELLE-M14-PLA-6.8 | 0 | E-6.8 | ECROU-M14-E-6.8 | 17 | 1 | 17 | M14*30
6 x Bolt assembly | 16 | 35 | 8.8 | 1 | PLA-8.8 | RONDELLE-M16-PLA-8.8 | 1 | E-8.8 | ECROU-M16-E-8.8 | 18 | 1 | 16 | M16*35
2 x Bolt assembly | 16 | 100 | 8.8 | 0 | PLA-8.8 | RONDELLE-M16-PLA-8.8 | 0 | E-8.8 | ECROU-M16-E-8.8 | 18 | 1 | 16 | M16*100
9 x Bolt assembly | 12 | 30 | SB8.8 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 1 | E-SB8.8 | ECROU-M12-E-SB8.8 | 14 | 1 | 12 | M12*30
17 x Bolt assembly | 12 | 25 | 8.8 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 2 | E-8.8 | ECROU-M12-E-8.8 | 14 | 2 | 12 | M12*25
11 x Bolt assembly | 12 | 25 | 8.8 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 3 | E-8.8 | ECROU-M12-E-8.8 | 14 | 3 | 12 | M12*25
3 x Bolt assembly | 12 | 30 | 8.8 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 3 | E-8.8 | ECROU-M12-E-8.8 | 14 | 3 | 12 | M12*30
5 x Bolt assembly | 12 | 50 | HR8.8 | 16 | PLA-HR8.8 | RONDELLE-M12-PLA-HR8.8 | 8 | E-HR8.8 | ECROU-M12-E-HR8.8 | 14 | 8 | 12 | M12*50
8 x Bolt assembly | 12 | 100 | 8.8 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 2 | E-8.8 | ECROU-M12-E-8.8 | 14 | 2 | 12 | M12*100
5 x Bolt assembly | 14 | 10 | 6.8 | 0 | PLA-6.8 | RONDELLE-M14-PLA-6.8 | 0 | E-6.8 | ECROU-M14-E-6.8 | 17 | 2 | 17 | M14*30
2 x Bolt assembly | 12 | 80 | 8.8 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 1 | E-8.8 | ECROU-M12-E-8.8 | 14 | 1 | 12 | M12*80
Bolt assembly | 12 | 30 | 8.8 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 1 | E-8.8 | ECROU-M12-E-8.8 | 14 | 1 | 12 | M12*30
13 x Bolt assembly | 12 | 25 | 8.8 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 1 | E-8.8 | ECROU-M12-E-8.8 | 14 | 1 | 12 | M12*25
2 x Bolt assembly | 12 | 100 | 8.8 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 1 | E-8.8 | ECROU-M12-E-8.8 | 14 | 1 | 12 | M12*100
11 x Bolt assembly | 12 | 6 | 8.8 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 0 | E-8.8 | ECROU-M12-E-8.8 | 14 | 1 | 14 | M12*25
7 x Bolt assembly | 12 | 30 | 8.8 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 2 | E-8.8 | ECROU-M12-E-8.8 | 14 | 2 | 12 | M12*30

# IfcMember: IPE140 (3)
In: Undefined
Description: IPE140; Material: STEEL/S235JR
Tekla Commun - Niveau bas: +1.868; Niveau haut: +2.072; Phase: 1; Classe: 1; Matériau: S235JR; Profil: IPE140; Nom: JARRET
Tekla Quantités - Poids: 5.4 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 42.8 m2; Surface nette: 0.1 m2; Hauteur: 125.2 mm; Largeur: 73 mm; Longueur: 422.7 mm
Pset_MemberCommon - LoadBearing: no
BaseQuantities - Length: 422.732 mm; OuterSurfaceArea: 0.232925 m2; GrossSurfaceArea: 0.232925 m2; CrossSectionArea: 0.00164 m2; NetVolume: 0.000494731 m3; GrossVolume: 0.000693281 m3; NetWeight: 3.88364 kg; GrossWeight: 5.44225 kg
Name | Repère de pièce = Reference | Repère d'assemblage
JARRET | 17 | A6(?)
JARRET | 17 | A24
JARRET | 2 | A20

# IfcMember: L60*4, CVT
In: Undefined
Description: L60*4; Material: STEEL/S235JR
Tekla Commun - Niveau bas: +2.216; Niveau haut: +2.463; Repère de pièce: A10; Repère d'assemblage: A10; Finition: GALVA; Phase: 11; Classe: 3; Matériau: S235JR; Profil: L60*4; Nom: CVT
Tekla Quantités - Poids: 1.5 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 64 m2; Surface nette: 0.1 m2; Hauteur: 60 mm; Largeur: 60 mm; Longueur: 422.3 mm
Pset_MemberCommon - LoadBearing: no; Reference: A10
BaseQuantities - Length: 422.325 mm; OuterSurfaceArea: 0.0984016 m2; GrossSurfaceArea: 0.113735 m2; CrossSectionArea: 0.000471508 m2; NetVolume: 0.000195959 m3; GrossVolume: 0.000218094 m3; NetWeight: 1.53827 kg; GrossWeight: 1.71204 kg

# IfcMember: TC-C50*50*3.2 (2)
In: Undefined
Description: TC-C50*50*3.2; Material: STEEL/S235JR
Tekla Commun - Niveau haut: +2.607; Finition: GALVA; Phase: 7; Classe: 13; Matériau: S235JR; Profil: TC-C50*50*3.2; Nom: TREILLIS
Tekla Quantités - Poids: 6 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 41.6 m2; Surface nette: 0.2 m2; Hauteur: 50 mm; Largeur: 50 mm
Pset_MemberCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000588 m2
Name | Niveau bas | Repère de pièce = Reference | Repère d'assemblage | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) = GrossSurfaceArea (m2) | NetVolume (m3) | GrossVolume (m3) | NetWeight (kg) | GrossWeight (kg)
TREILLIS | +2.166 | aa17 | A14 | 1307.5 | 1307.52 | 0.251043 | 0.000711069 | 0.00076882 | 5.58189 | 6.03524
TREILLIS | +2.170 | A16 | A16 | 1301.7 | 1301.74 | 0.249933 | 0.000704907 | 0.000765421 | 5.53352 | 6.00855

# IfcMember: TUBE-C-50*50*3 (2)
In: Undefined
Description: TUBE-C-50*50*3; Material: STEEL/S235JR
Tekla Commun - Niveau bas: +0.355; Niveau haut: +2.066; Finition: GALVA; Phase: 1; Classe: 3; Matériau: S235JR; Profil: TUBE-C-50*50*3; Nom: CVT
Tekla Quantités - Poids: 8.6 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 44.5 m2; Surface nette: 0.3 m2; Hauteur: 50 mm; Largeur: 50 mm; Longueur: 2030.2 mm
Pset_MemberCommon - LoadBearing: no
BaseQuantities - Length: 2030.2 mm; OuterSurfaceArea: 0.383708 m2; GrossSurfaceArea: 0.383708 m2; CrossSectionArea: 0.000541 m2; NetVolume: 0.00114209 m3; GrossVolume: 0.00109834 m3; NetWeight: 8.96544 kg; GrossWeight: 8.62197 kg
Name | Repère de pièce = Repère d'assemblage = Reference
CVT | A4
CVT | A45

# IfcPlate: PL 60*6 (8)
In: Undefined
Description: PL 60*6; Material: STEEL/S235JR
Tekla Commun - Finition: GALVA; Classe: 2; Matériau: S235JR; Profil: PL 60*6; Nom: TREILLIS
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 48.8 m2; Surface nette: 0 m2; Hauteur: 60 mm; Largeur: 6 mm; Longueur: 124 mm
Pset_PlateCommon - Support de charge: no
BaseQuantities - Width: 60 mm; NetArea: 0.017088 m2; GrossArea: 0.017088 m2; CrossSectionArea: 0.00036 m2; NetVolume: 0.00004464 m3; GrossVolume: 0.00004464 m3
Name | Niveau bas | Niveau haut | Repère de pièce = Réference | Repère d'assemblage | Phase | Poids (kg)
2 x TREILLIS | +2.070 | +2.130 | 13 | A1 | 1 | 0.4
2 x TREILLIS | +2.606 | +2.666 | 13 | A23(?) | 1 | 0.4
 | +2.111 | +2.171 | (?) |  | 1 | 0
TREILLIS | +2.115 | +2.175 | aa58 | A14 | 7 | 0.4
2 x TREILLIS | +2.070 | +2.130 | 13 | A2 | 1 | 0.4

# IfcPlate: PL 60*7 (5)
In: Undefined
Description: PL 60*7; Material: STEEL/S235JR
Tekla Commun - Repère de pièce: (?); Finition: GALVA; Phase: 1; Classe: 2; Matériau: S235JR; Profil: PL 60*7; Nom: TREILLIS
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0 m2; Hauteur: 60 mm; Largeur: 7 mm
Pset_PlateCommon - Support de charge: no; Réference: (?)
BaseQuantities - Width: 60 mm; CrossSectionArea: 0.00042 m2
Name | Niveau bas | Niveau haut | Surface par tonne (m2) | Longueur (mm) | NetArea (m2) = GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
 | +2.606 | +2.666 | 42.3 | 154 | 0.021476 | 0.00006468
4 x  | +2.070 | +2.130 | 42.7 | 124 | 0.017456 | 0.00005208

# IfcPlate: PL 90*6 (7)
In: Undefined
Description: PL 90*6; Material: STEEL/S235JR
Tekla Commun - Finition: GALVA; Phase: 1; Classe: 6; Matériau: S235JR; Profil: PL 90*6; Nom: SUPPORT V TREILLIS
Tekla Quantités - Poids: 0.4 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 47.7 m2; Surface nette: 0 m2; Hauteur: 90 mm; Largeur: 6 mm; Longueur: 120 mm
Pset_PlateCommon - Support de charge: no
BaseQuantities - Width: 90 mm; NetArea: 0.0213962 m2; GrossArea: 0.02412 m2; CrossSectionArea: 0.00054 m2; NetVolume: 0.00005715 m3; GrossVolume: 0.0000648 m3
Name | Niveau bas | Niveau haut | Repère de pièce = Réference | Repère d'assemblage
SUPPORT V TREILLIS | +2.010 | +2.130 | 14 | A5(?)
SUPPORT V TREILLIS | +2.546 | +2.666 | 14 | A29
SUPPORT V TREILLIS | +2.546 | +2.666 | 14 | A30
SUPPORT V TREILLIS | +2.055 | +2.175 | aa57 | A30
SUPPORT V TREILLIS | +2.010 | +2.130 | 14 | A7
2 x SUPPORT V TREILLIS | +2.010 | +2.130 | 14 | A32

# IfcPlate: PL10*140 (5)
In: Undefined
Description: PL10*140; Material: STEEL/S235JR
Tekla Commun - Niveau bas: +0.200; Niveau haut: +0.210; Phase: 1; Classe: 99; Matériau: S235JR; Profil: PL10*140
Tekla Quantités - Poids: 1.5 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 29.1 m2; Surface nette: 0 m2; Hauteur: 140 mm; Largeur: 10 mm; Longueur: 140 mm
Pset_PlateCommon - Support de charge: no
BaseQuantities - Width: 140 mm; NetArea: 0.0448 m2; GrossArea: 0.0448 m2; CrossSectionArea: 0.0014 m2; NetVolume: 0.000196 m3; GrossVolume: 0.000196 m3
Name | Repère de pièce = Réference | Repère d'assemblage
Unnamed | 5 | A5(?)
Unnamed | 3 | A29
Unnamed | 3 | A32
Unnamed | 3 | A7
Unnamed | 5 | A30

# IfcPlate: PL10*40 (10)
In: Undefined
Description: PL10*40; Material: STEEL/S235JR
Tekla Commun - Phase: 1; Classe: 1; Matériau: S235JR; Profil: PL10*40; Nom: PLAT
Tekla Quantités - Poids: 0.2 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 34.9 m2; Surface nette: 0 m2; Hauteur: 40 mm; Largeur: 10 mm; Longueur: 80 mm
Pset_PlateCommon - Support de charge: no
BaseQuantities - Width: 40 mm; NetArea: 0.00837141 m2; GrossArea: 0.0032 m2; CrossSectionArea: 0.0001 m2; NetVolume: 0.00003056 m3; GrossVolume: 0.00003056 m3
Name | Niveau bas | Niveau haut | Repère de pièce = Réference | Repère d'assemblage
2 x PLAT | +1.859 | +1.869 | 19 | A32
2 x PLAT | +1.859 | +1.869 | 19 | A5(?)
2 x PLAT | +2.404 | +2.414 | 4 | A29
2 x PLAT | +1.859 | +1.869 | 4 | A7
2 x PLAT | +2.404 | +2.414 | 4 | A30

# IfcPlate: PL12*98 (5)
In: Undefined
Description: PL12*98; Material: STEEL/S235JR
Tekla Commun - Phase: 1; Classe: 1; Matériau: S235JR; Profil: PL12*98; Nom: PLAT
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 24.7 m2; Surface nette: 0.1 m2; Hauteur: 98 mm; Largeur: 12 mm
Pset_PlateCommon - Support de charge: no
BaseQuantities - Width: 98 mm; CrossSectionArea: 0.001176 m2
Name | Niveau bas | Niveau haut | Repère de pièce = Réference | Repère d'assemblage | Poids (kg) | Longueur (mm) | NetArea (m2) = GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLAT | +1.872 | +2.169 | 18 | A6(?) | 2.7 | 296.4 | 0.0675682 | 0.00034861
PLAT | +1.872 | +2.169 | 18 | A24 | 2.7 | 296.4 | 0.0675682 | 0.00034861
PLAT | +2.412 | +2.678 | 12 | A24 | 2.5 | 265.4 | 0.0607424 | 0.000312123
PLAT | +1.872 | +2.169 | 10 | A20 | 2.7 | 296.4 | 0.0675682 | 0.00034861
PLAT | +2.412 | +2.678 | 9 | A20 | 2.5 | 265.4 | 0.0607424 | 0.000312123

# IfcPlate: PL6*100 (14)
In: Undefined
Description: PL6*100; Material: STEEL/S235JR
Tekla Commun - Finition: GALVA; Classe: 5; Matériau: S235JR; Profil: PL6*100; Nom: Support-Lisse
Tekla Quantités - Poids: 0.6 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 47.3 m2; Surface nette: 0 m2; Hauteur: 100 mm; Largeur: 6 mm; Longueur: 126 mm
Pset_PlateCommon - Support de charge: no
BaseQuantities - Width: 100 mm; NetArea: 0.0281767 m2; GrossArea: 0.012596 m2; CrossSectionArea: 0.000036 m2; NetVolume: 0.0000759 m3; GrossVolume: 0.0000759 m3
Name | Niveau bas | Niveau haut | Repère de pièce = Réference | Repère d'assemblage | Phase
2 x Support-Lisse | +0.310 | +0.380 | A36 | A36 | 1
2 x Support-Lisse | +1.610 | +1.680 | A36 | A36 | 1
2 x Support-Lisse | +0.310 | +0.380 | A37 | A37 | 1
2 x Support-Lisse | +1.610 | +1.680 | A37 | A37 | 1
Support-Lisse | +0.310 | +0.380 | A43 | A43 | 1
2 x Support-Lisse | +0.310 | +0.380 | 0 | 0(?) | 12
2 x Support-Lisse | +1.610 | +1.680 | 0 | 0(?) | 12
Support-Lisse | +1.610 | +1.680 | A34 | A34 | 1

# IfcPlate: PL6*112, GOUSSET
In: Undefined
Description: PL6*112; Material: STEEL/S235JR
Tekla Commun - Niveau bas: +2.371; Niveau haut: +2.493; Repère de pièce: 15(?); Repère d'assemblage: A6(?); Phase: 1; Classe: 99; Matériau: S235JR; Profil: PL6*112; Nom: GOUSSET
Tekla Quantités - Poids: 0.4 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 53.7 m2; Surface nette: 0 m2; Hauteur: 112 mm; Largeur: 6 mm; Longueur: 150 mm
Pset_PlateCommon - Support de charge: no; Réference: 15(?)
BaseQuantities - Width: 112 mm; NetArea: 0.0277616 m2; GrossArea: 0.0168 m2; CrossSectionArea: 0.000036 m2; NetVolume: 0.0000658926 m3; GrossVolume: 0.0001008 m3

# IfcPlate: PL6*140 (2)
In: Undefined
Description: PL6*140; Material: STEEL/S235JR
Tekla Commun - Niveau bas: +1.988; Niveau haut: +2.128; Repère de pièce: aa38; Repère d'assemblage: A1; Phase: 1; Classe: 99; Matériau: S235JR; Profil: PL6*140; Nom: GOUSSET
Tekla Quantités - Poids: 1 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 45.8 m2; Surface nette: 0 m2; Hauteur: 140 mm; Largeur: 6 mm; Longueur: 170 mm
Pset_PlateCommon - Support de charge: no; Réference: aa38
BaseQuantities - Width: 140.004 mm; NetArea: 0.0478878 m2; GrossArea: 0.0238007 m2; CrossSectionArea: 0.000036 m2; NetVolume: 0.000133317 m3; GrossVolume: 0.000142804 m3

# IfcPlate: PL6*250, TOLE
In: Undefined
Description: PL6*250; Material: STEEL/S235JR
Pset_PlateCommon - Support de charge: no; Réference: E0
Tekla Commun - Niveau bas: +2.131; Niveau haut: +2.175; Repère de pièce: E0; Repère d'assemblage: E0(?); Phase: 1; Classe: 6; Matériau: S235JR; Profil: PL6*250; Nom: TOLE
Tekla Quantités - Poids: 2 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 44.8 m2; Surface nette: 0.1 m2; Hauteur: 250.3 mm; Largeur: 6 mm; Longueur: 216 mm
BaseQuantities - Width: 250.272 mm; NetArea: 0.0904767 m2; GrossArea: 0.0540587 m2; CrossSectionArea: 0.000036 m2; NetVolume: 0.000256992 m3; GrossVolume: 0.000256992 m3

# IfcPlate: PL6*267 (7)
In: Undefined
Description: PL6*267; Material: STEEL/S235JR
Tekla Commun - Finition: GALVA; Phase: 1; Classe: 6; Matériau: S235JR; Profil: PL6*267
Tekla Quantités - Poids: 2.8 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 44.9 m2; Surface nette: 0.1 m2; Hauteur: 266.7 mm; Largeur: 6 mm; Longueur: 300.4 mm
Pset_PlateCommon - Support de charge: no
BaseQuantities - Width: 266.697 mm; NetArea: 0.126682 m2; GrossArea: 0.0801064 m2; CrossSectionArea: 0.000036 m2
Name | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Réference | Nom | NetVolume (m3) = GrossVolume (m3)
GOUSSET_ENROULE2 | +2.325 | +2.419 | A11 | GOUSSET_ENROULE2 | 0.000359593
GOUSSET_ENROULE2 | +2.278 | +2.418 | A9 | GOUSSET_ENROULE2 | 0.00035959
GOUSSET_ENROULE2 | +2.325 | +2.419 | A41 | GOUSSET_ENROULE2 | 0.000359591
GOUSSET_ENROULE2 | +2.278 | +2.418 | A42 | GOUSSET_ENROULE2 | 0.000359594
GOUSSET_ENROULE2 | +2.092 | +2.186 | A8 | GOUSSET_ENROULE2 | 0.000359593
GOUSSET_ENROULE1 | +2.511 | +2.651 | A19 | GOUSSET_ENROULE1 | 0.00035959
GOUSSET_ENROULE4 | +2.512 | +2.651 | A21 | GOUSSET_ENROULE4 | 0.000359594

# IfcPlate: PL6*50 (10)
In: Undefined
Description: PL6*50; Material: STEEL/S235JR
Tekla Commun - Niveau bas: +0.210; Niveau haut: +0.216; Repère de pièce: E0; Repère d'assemblage: E0(?); Phase: 1; Classe: 1; Matériau: S235JR; Profil: PL6*50; Nom: Washer Plate
Tekla Quantités - Poids: 0.1 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 52.7 m2; Surface nette: 0 m2; Hauteur: 50 mm; Largeur: 6 mm; Longueur: 50 mm
Pset_PlateCommon - Support de charge: no; Réference: E0
BaseQuantities - Width: 50 mm; NetArea: 0.0062 m2; GrossArea: 0.0025 m2; CrossSectionArea: 0.000036 m2; NetVolume: 0.000015 m3; GrossVolume: 0.000015 m3

# IfcPlate: PL6*60 (2)
In: Undefined
Description: PL6*60; Material: STEEL/S235JR
Tekla Quantités - Poids: 0.4 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 48.8 m2; Surface nette: 0 m2; Hauteur: 60 mm; Largeur: 6 mm; Longueur: 124 mm
Tekla Commun - Niveau bas: +0.308; Niveau haut: +0.444; Phase: 1; Classe: 99; Matériau: S235JR; Profil: PL6*60; Nom: GOUSSET
Pset_PlateCommon - Support de charge: no
BaseQuantities - Width: 60 mm; NetArea: 0.017088 m2; GrossArea: 0.00744 m2; CrossSectionArea: 0.000036 m2; NetVolume: 0.00004464 m3; GrossVolume: 0.00004464 m3
Name | Repère de pièce = Repère d'assemblage = Réference
GOUSSET | A27(?)
GOUSSET | A0(?)

# IfcPlate: PL6*85 (6)
In: Undefined
Description: PL6*85; Material: STEEL/S235JR
Tekla Commun - Repère de pièce: A39; Repère d'assemblage: A39; Phase: 1; Classe: 99; Matériau: S235JR; Profil: PL6*85; Nom: GOUSSET
Tekla Quantités - Poids: 0.6 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 47.2 m2; Surface nette: 0 m2; Hauteur: 85 mm; Largeur: 6 mm; Longueur: 167.6 mm
Pset_PlateCommon - Support de charge: no; Réference: A39
BaseQuantities - Width: 85 mm; NetArea: 0.0317479 m2; GrossArea: 0.0142472 m2; CrossSectionArea: 0.000036 m2; NetVolume: 0.0000856615 m3; GrossVolume: 0.0000856615 m3
Name | Niveau bas | Niveau haut
2 x GOUSSET | +2.085 | +2.181
2 x GOUSSET | +2.551 | +2.648
2 x GOUSSET | +2.318 | +2.414

# IfcPlate: PL6*91 (2)
In: Undefined
Description: PL6*91; Material: STEEL/S235JR
Tekla Commun - Niveau bas: +0.291; Niveau haut: +0.382; Repère de pièce: aa36; Phase: 1; Classe: 99; Matériau: S235JR; Profil: PL6*91; Nom: GOUSSET
Tekla Quantités - Poids: 0.4 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 48 m2; Surface nette: 0 m2; Hauteur: 90.7 mm; Largeur: 6 mm; Longueur: 100.3 mm
Pset_PlateCommon - Support de charge: no; Réference: aa36
BaseQuantities - Width: 90.6976 mm; NetArea: 0.0186712 m2; GrossArea: 0.00909467 m2; CrossSectionArea: 0.000036 m2; NetVolume: 0.000049558 m3; GrossVolume: 0.000049558 m3
Name | Repère d'assemblage
GOUSSET | A32
GOUSSET | A5(?)

# IfcPlate: PL7*95, GOUSSET
In: Undefined
Description: PL7*95; Material: STEEL/S235JR
Tekla Commun - Niveau bas: +2.181; Niveau haut: +2.296; Repère de pièce: aa8; Repère d'assemblage: A14; Phase: 7; Classe: 99; Matériau: S235JR; Profil: PL7*95; Nom: GOUSSET
Tekla Quantités - Poids: 0.4 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 42.4 m2; Surface nette: 0 m2; Hauteur: 95 mm; Largeur: 7 mm; Longueur: 115 mm
Pset_PlateCommon - Support de charge: no; Réference: aa8
BaseQuantities - Width: 95.0001 mm; NetArea: 0.0175711 m2; GrossArea: 0.010925 m2; CrossSectionArea: 0.000049 m2; NetVolume: 0.0000527295 m3; GrossVolume: 0.000076475 m3

# IfcPlate: PL8*90 (5)
In: Undefined
Description: PL8*90; Material: STEEL/S235JR
Tekla Commun - Phase: 1; Classe: 1; Matériau: S235JR; Profil: PL8*90; Nom: PLAT
Tekla Quantités - Poids: 0.4 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 37.6 m2; Surface nette: 0 m2; Hauteur: 90 mm; Largeur: 8 mm; Longueur: 88 mm
Pset_PlateCommon - Support de charge: no
BaseQuantities - Width: 90 mm; NetArea: 0.018688 m2; GrossArea: 0.018688 m2; CrossSectionArea: 0.00072 m2; NetVolume: 0.00006336 m3; GrossVolume: 0.00006336 m3
Name | Niveau bas | Niveau haut | Repère de pièce = Réference | Repère d'assemblage
PLAT | +2.162 | +2.170 | 16 | A32
PLAT | +2.162 | +2.170 | 16 | A5(?)
PLAT | +2.675 | +2.683 | 8 | A29
PLAT | +2.162 | +2.170 | 8 | A7
PLAT | +2.675 | +2.683 | 8 | A30
