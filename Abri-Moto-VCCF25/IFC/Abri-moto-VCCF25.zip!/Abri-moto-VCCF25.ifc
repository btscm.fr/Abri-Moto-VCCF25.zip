Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:Off], Option [Assemblies:On], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:Off], Option [LocationBy:0], Option [ViewColors:On], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: Abri-moto-VCCF25.ifc
Time: 2025-03-14T01:12:15
Author: BOINEAUP\Administrateur
Organization: Structural Designer
Written by: IFC Parser Version: 3.13.2
Made in: Tekla Structures Educational 2023 Service Pack 4, IFC Export Version: 4.0.0.0 Jun 12 2023

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: CC100-2-15-50 (6)
In: Undefined
Description: CC100-2-15-50; Material: STEEL/S235JR
Tekla Commun - Phase: 1; Classe: 9; Matériau: S235JR; Profil: CC100-2-15-50; Nom: C_JORIS100
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 128.6 m2; Surface nette: 1.1 m2; Hauteur: 100 mm; Largeur: 50 mm
Pset_BeamCommon - LoadBearing: no
Name | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Poids (kg) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
C_JORIS100 | +2.321 | +2.428 | A31(?) | 8.5 | 2403.5 | 2403.5 | 1.07766 | 0.00106715 | 8.37716
C_JORIS100 | +2.087 | +2.195 | A22(?) | 8.5 | 2401.2 | 2401.15 | 1.0766 | 0.00106611 | 8.36898
C_JORIS100 | +2.321 | +2.428 | A13 | 8.5 | 2403.5 | 2403.5 | 1.07766 | 0.00106715 | 8.37716
C_JORIS100 | +2.554 | +2.661 | A26 | 8.5 | 2403.5 | 2403.5 | 1.07766 | 0.00106716 | 8.37717
C_JORIS100 | +2.087 | +2.195 | A33 | 8.5 | 2407 | 2407 | 1.07922 | 0.00106871 | 8.38936
C_JORIS100 | +2.554 | +2.661 | A49(?) | 8.3 | 2393.5 | 2393.5 | 1.07318 | 0.00106271 | 8.3423

# IfcBeam: IPE140 (4)
In: Undefined
Description: IPE140; Material: STEEL/S235JR
Tekla Commun - Phase: 1; Matériau: S235JR; Profil: IPE140
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 42.8 m2; Largeur: 73 mm
Pset_BeamCommon - LoadBearing: no
Name | Niveau bas | Niveau haut | Repère de pièce = Reference | Repère d'assemblage | Finition | Classe | Nom | Poids (kg) | Surface nette (m2) | Hauteur (mm) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
ARBA | +2.030 | +2.686 | aa33(?) | A6(?) | GALVA | 4 | ARBA | 38.3 | 1.7 | 140 | 2978.8 | 2978.81 | 1.64133 | 0.00472811 | 37.1157
JARRET | +2.408 | +2.539 | 11 | A24 |  | 1 | JARRET | 3.9 | 0.1 | 123.5 | 300.1 | 300.146 | 0.16538 | 0.000405188 | 3.18073
ARBA | +2.030 | +2.681 | aa14 | A24 | GALVA | 4 | ARBA | 38 | 1.6 | 140 | 2949.4 | 2949.36 | 1.6251 | 0.00468098 | 36.7457
ARBA | +2.030 | +2.683 | aa13(?) | A20(?) | GALVA | 4 | ARBA | 38.1 | 1.7 | 140 | 2960.8 | 2960.83 | 1.63142 | 0.00471912 | 37.0451

# IfcBeam: L45*4 (2)
In: Undefined
Description: L45*4; Material: STEEL/S235JR
Tekla Commun - Phase: 1; Classe: 5; Matériau: S235JR; Profil: L45*4; Nom: CORNIERE
Tekla Quantités - Poids: 0.4 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 63.5 m2; Surface nette: 0 m2; Hauteur: 45 mm; Largeur: 45 mm; Longueur: 170 mm
Pset_BeamCommon - LoadBearing: no
BaseQuantities - Length: 170 mm; OuterSurfaceArea: 0.02958 m2; NetVolume: 0.00005848 m3; NetWeight: 0.459068 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference
CORNIERE | +2.138 | +2.183 | 4
CORNIERE | +2.095 | +2.169 | 3

# IfcBeam: L60*4 (4)
In: Undefined
Description: L60*4; Material: STEEL/S235JR
Tekla Commun - Finition: GALVA; Phase: 1; Classe: 3; Matériau: S235JR; Profil: L60*4; Nom: CVT
Tekla Quantités - Poids: 9.1 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 64 m2; Surface nette: 0.6 m2; Hauteur: 60 mm; Largeur: 60 mm
Pset_BeamCommon - LoadBearing: no
Name | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
CVT | +2.081 | +2.355 | A40(?) | 2502.3 | 2502.28 | 0.583031 | 0.00116106 | 9.1143
CVT | +2.324 | +2.589 | A35(?) | 2497.7 | 2497.72 | 0.581969 | 0.00115894 | 9.09769
CVT | +2.324 | +2.589 | A38(?) | 2498.2 | 2498.24 | 0.58209 | 0.00115918 | 9.09958
CVT | +2.082 | +2.355 | A35(?) | 2498.2 | 2498.24 | 0.58209 | 0.00115918 | 9.09959

# IfcBeam: L60*60*6, CAI-Att-FA
In: Undefined
Description: L60*60*6; Material: STEEL/S235JR
Tekla Commun - Niveau bas: +2.586; Niveau haut: +2.661; Repère de pièce: A48(?); Repère d'assemblage: A48(?); Phase: 1; Classe: 3; Matériau: S235JR; Profil: L60*60*6; Nom: CAI-Att-FA
Tekla Quantités - Poids: 0.4 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 48.1 m2; Surface nette: 0 m2; Hauteur: 60 mm; Largeur: 60 mm; Longueur: 75 mm
Pset_BeamCommon - LoadBearing: no; Reference: A48(?)
BaseQuantities - Length: 75 mm; OuterSurfaceArea: 0.019368 m2; NetVolume: 0.0000513 m3; NetWeight: 0.402705 kg

# IfcBeam: PL6*100 (14)
In: Undefined
Description: PL6*100; Material: STEEL/S235JR
Tekla Commun - Finition: GALVA; Classe: 5; Matériau: S235JR; Profil: PL6*100; Nom: Support-Lisse
Tekla Quantités - Poids: 0.6 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 47.3 m2; Surface nette: 0 m2; Hauteur: 100 mm; Largeur: 6 mm; Longueur: 126 mm
Pset_BeamCommon - LoadBearing: no
BaseQuantities - Length: 125.96 mm; OuterSurfaceArea: 0.0281767 m2; NetVolume: 0.0000759 m3; NetWeight: 0.595815 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Phase
2 x Support-Lisse | +0.310 | +0.380 | A36 | 1
2 x Support-Lisse | +1.610 | +1.680 | A36(?) | 1
2 x Support-Lisse | +0.310 | +0.380 | A37 | 1
2 x Support-Lisse | +1.610 | +1.680 | A37(?) | 1
Support-Lisse | +0.310 | +0.380 | A43 | 1
Support-Lisse | +0.310 | +0.380 | 1(?) | 12
Support-Lisse | +0.310 | +0.380 | 2(?) | 12
Support-Lisse | +1.610 | +1.680 | 2 | 12
Support-Lisse | +1.610 | +1.680 | A34(?) | 1
Support-Lisse | +1.610 | +1.680 | 1 | 12

# IfcBeam: PL6*267 (7)
In: Undefined
Description: PL6*267; Material: STEEL/S235JR
Tekla Commun - Finition: GALVA; Phase: 1; Matériau: S235JR; Profil: PL6*267
Tekla Quantités - Poids: 2.8 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 44.9 m2; Surface nette: 0.1 m2; Hauteur: 266.7 mm; Largeur: 6 mm; Longueur: 300.4 mm
Pset_BeamCommon - LoadBearing: no
BaseQuantities - Length: 300.365 mm; OuterSurfaceArea: 0.126682 m2
Name | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Classe | Nom | NetVolume (m3) | NetWeight (kg)
GOUSSET_ENROULE2 | +2.316 | +2.410 | A9(?) | 2 | GOUSSET_ENROULE2 | 0.000359589 | 2.82277
GOUSSET_ENROULE2 | +2.325 | +2.419 | A11(?) | 11 | GOUSSET_ENROULE2 | 0.000359595 | 2.82282
GOUSSET_ENROULE2 | +2.278 | +2.418 | A9(?) | 2 | GOUSSET_ENROULE2 | 0.000359589 | 2.82277
GOUSSET_ENROULE2 | +2.325 | +2.419 | A41(?) | 6 | GOUSSET_ENROULE2 | 0.000359591 | 2.82279
GOUSSET_ENROULE2 | +2.092 | +2.186 | A8(?) | 11 | GOUSSET_ENROULE2 | 0.000359593 | 2.8228
GOUSSET_ENROULE1 | +2.511 | +2.651 | A19(?) | 2 | GOUSSET_ENROULE1 | 0.00035959 | 2.82278
GOUSSET_ENROULE4 | +2.512 | +2.651 | A21(?) | 11 | GOUSSET_ENROULE4 | 0.000359594 | 2.82281

# IfcBeam: PL6*85 (6)
In: Undefined
Description: PL6*85; Material: STEEL/S235JR
Tekla Commun - Phase: 1; Classe: 99; Matériau: S235JR; Profil: PL6*85; Nom: GOUSSET
Tekla Quantités - Poids: 0.6 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 47.2 m2; Surface nette: 0 m2; Hauteur: 85 mm; Largeur: 6 mm; Longueur: 167.6 mm
Pset_BeamCommon - LoadBearing: no
BaseQuantities - Length: 167.614 mm; OuterSurfaceArea: 0.0317479 m2; NetVolume: 0.0000856615 m3; NetWeight: 0.672443 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference
GOUSSET | +2.085 | +2.181 | A39
2 x GOUSSET | +2.551 | +2.648 | A39
GOUSSET | +2.085 | +2.181 | A0(?)
2 x GOUSSET | +2.318 | +2.414 | A39

# IfcBeam: TC-C50*50*3.2 (2)
In: Undefined
Description: TC-C50*50*3.2; Material: STEEL/S235JR
Tekla Commun - Repère d'assemblage: A16(?); Finition: GALVA; Phase: 1; Classe: 13; Matériau: S235JR; Profil: TC-C50*50*3.2; Nom: TREILLIS
Tekla Quantités - Poids: 22.2 kg; Volume: 0 m3; Surface supérieure totale: 0.2 m2; Surface par tonne: 41.6 m2; Surface nette: 1 m2; Hauteur: 50 mm; Largeur: 50 mm; Longueur: 4805 mm
Pset_BeamCommon - LoadBearing: no
Name | Niveau bas | Niveau haut | Repère de pièce = Reference | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
TREILLIS | +2.120 | +2.170 | aa9(?) | 4805 | 0.92256 | 0.00287301 | 22.5531
TREILLIS | +2.611 | +2.661 | aa30(?) | 4805.01 | 0.922562 | 0.00286591 | 22.4974

# IfcBeam: TUBE-C-50*50*3 (2)
In: Undefined
Description: TUBE-C-50*50*3; Material: STEEL/S235JR
Tekla Commun - Niveau bas: +2.075; Niveau haut: +2.125; Repère de pièce: aa20; Finition: GALVA; Phase: 1; Classe: 3; Matériau: S235JR; Profil: TUBE-C-50*50*3; Nom: CVT
Tekla Quantités - Poids: 9.8 kg; Volume: 0 m3; Surface supérieure totale: 0.1 m2; Surface par tonne: 44.5 m2; Surface nette: 0.4 m2; Hauteur: 50 mm; Largeur: 50 mm; Longueur: 2305 mm
Pset_BeamCommon - LoadBearing: no; Reference: aa20
BaseQuantities - Length: 2305 mm; OuterSurfaceArea: 0.435645 m2; NetVolume: 0.00129414 m3; NetWeight: 10.159 kg
Name | Repère d'assemblage
CVT | A2
CVT | A1(?)

# IfcBeam: TUBE-R-70*40*3 (8)
In: Undefined
Description: TUBE-R-70*40*3; Material: STEEL/S235JR
Tekla Commun - Finition: GALVA; Phase: 1; Classe: 6; Matériau: S235JR; Profil: TUBE-R-70*40*3; Nom: LISSES
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0.2 m2; Surface par tonne: 42.9 m2; Hauteur: 70 mm; Largeur: 40 mm
Pset_BeamCommon - LoadBearing: no
Name | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Poids (kg) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
LISSES | +1.680 | +1.720 | A44 | 14 | 0.6 | 2874 | 2873.99 | 0.600665 | 0.00177316 | 13.9193
LISSES | +0.380 | +0.420 | A44 | 14 | 0.6 | 2874 | 2873.99 | 0.600665 | 0.00177316 | 13.9193
LISSES | +1.680 | +1.720 | A18 | 14 | 0.6 | 2874 | 2873.99 | 0.600665 | 0.00177316 | 13.9193
LISSES | +0.380 | +0.420 | A18 | 14 | 0.6 | 2874 | 2873.99 | 0.600665 | 0.00177316 | 13.9193
LISSES | +1.680 | +1.720 | A28 | 12.4 | 0.4 | 2537.5 | 2537.5 | 0.530338 | 0.00156319 | 12.271
LISSES | +0.380 | +0.420 | A28 | 12.4 | 0.4 | 2537.5 | 2537.5 | 0.530338 | 0.00156319 | 12.271
LISSES | +1.680 | +1.720 | A3 | 12.4 | 0.4 | 2537.5 | 2537.5 | 0.530338 | 0.00156319 | 12.271
LISSES | +0.380 | +0.420 | A3 | 12.4 | 0.4 | 2537.5 | 2537.5 | 0.530338 | 0.00156319 | 12.271

# IfcColumn: 250*250 (5)
In: Undefined
Description: 250*250; Material: CONCRETE/C25/30
Tekla Commun - Niveau bas: +0.000; Niveau haut: +0.200; Repère de pièce: Pt1; Repère d'assemblage: Pt1; Phase: 1; Classe: 13; Matériau: C25/30; Profil: 250*250; Nom: POTEAU
Tekla Quantités - Poids: 30 kg; Volume: 0 m3; Surface supérieure totale: 0.1 m2; Surface par tonne: 10.8 m2; Surface nette: 0.4 m2; Hauteur: 250 mm; Largeur: 250 mm; Longueur: 200 mm
Pset_ColumnCommon - LoadBearing: no; Reference: Pt1
BaseQuantities - Length: 200 mm; OuterSurfaceArea: 0.325 m2; NetVolume: 0.0125 m3; NetWeight: 30 kg

# IfcColumn: D14 (10)
In: Undefined
Description: D14; Material: STEEL/S235JR
Tekla Commun - Niveau bas: +0.040; Niveau haut: +0.240; Repère de pièce: B1; Repère d'assemblage: B1; Phase: 1; Classe: 1; Matériau: S235JR; Profil: D14; Nom: BARRE
Tekla Quantités - Poids: 0.2 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 40.7 m2; Surface nette: 0 m2; Hauteur: 14 mm; Largeur: 14 mm; Longueur: 200 mm
Pset_ColumnCommon - LoadBearing: no; Reference: B1
BaseQuantities - Length: 200 mm; OuterSurfaceArea: 0.00884929 m2; NetVolume: 0.0000277186 m3; NetWeight: 0.217591 kg

# IfcColumn: HEA100 (5)
In: Undefined
Description: HEA100; Material: STEEL/S235JR
Tekla Commun - Niveau bas: +0.210; Finition: GALVA; Phase: 1; Classe: 4; Matériau: S235JR; Profil: HEA100
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 33.6 m2; Hauteur: 96 mm; Largeur: 100 mm
Pset_ColumnCommon - LoadBearing: no
Name | Niveau haut | Repère de pièce = Reference | Repère d'assemblage | Nom | Poids (kg) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
POTEAU AV | +2.162 | aa18(?) | A5(?) | POTEAU AV | 32.5 | 1.1 | 1951.7 | 1951.74 | 1.09493 | 0.00390348 | 30.6423
POTEAU AV | +2.675 | aa2(?) | A29(?) | POTEAU AV | 41.1 | 1.4 | 2464.9 | 2464.92 | 1.38282 | 0.00492984 | 38.6992
POTEAU AV | +2.162 | aa4(?) | A32(?) | POTEAU AV | 32.5 | 1.1 | 1951.7 | 1951.74 | 1.09493 | 0.00390348 | 30.6423
Poteau AR | +2.162 | aa1(?) | A7(?) | Poteau AR | 32.5 | 1.1 | 1951.7 | 1951.74 | 1.09493 | 0.00390348 | 30.6423
POTEAU AV | +2.700 | aa3(?) | A30(?) | POTEAU AV | 41.5 | 1.4 | 2490 | 2490 | 1.39689 | 0.00498 | 39.093

# IfcColumn: L60*60*6, CAI-Att-FA
In: Undefined
Description: L60*60*6; Material: STEEL/S235JR
BaseQuantities - Length: 75 mm; OuterSurfaceArea: 0.019368 m2; NetVolume: 0.0000513 m3; NetWeight: 0.402705 kg
Tekla Commun - Niveau bas: +2.586; Niveau haut: +2.661; Repère de pièce: A46(?); Repère d'assemblage: A46(?); Phase: 1; Classe: 3; Matériau: S235JR; Profil: L60*60*6; Nom: CAI-Att-FA
Tekla Quantités - Poids: 0.4 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 48.1 m2; Surface nette: 0 m2; Hauteur: 60 mm; Largeur: 60 mm; Longueur: 75 mm
Pset_ColumnCommon - LoadBearing: no; Reference: A46(?)

# IfcColumn: PD28*7 (10)
In: Undefined
Description: PD28*7; Material: STEEL/S235JR
Tekla Commun - Niveau bas: +0.216; Niveau haut: +0.230; Repère de pièce: E3; Repère d'assemblage: E3; Phase: 1; Classe: 1; Matériau: S235JR; Profil: PD28*7; Nom: ECROU
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 37.3 m2; Surface nette: 0 m2; Hauteur: 28 mm; Largeur: 28 mm; Longueur: 14 mm
Pset_ColumnCommon - LoadBearing: no; Reference: E3
BaseQuantities - Length: 14 mm; OuterSurfaceArea: 0.00180548 m2; NetVolume: 0.000006174 m3; NetWeight: 0.0484659 kg

# IfcColumn: TC-C50*50*3.2 (4)
In: Undefined
Description: TC-C50*50*3.2; Material: STEEL/S235JR
Tekla Commun - Finition: GALVA; Phase: 1; Classe: 13; Matériau: S235JR; Profil: TC-C50*50*3.2; Nom: TREILLIS
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2
Pset_ColumnCommon - LoadBearing: no
Name | Niveau bas | Niveau haut | Repère de pièce = Reference | Repère d'assemblage | Poids (kg) | Surface par tonne (m2) | Surface nette (m2) | Hauteur (mm) = Largeur (mm) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x TREILLIS | +2.170 | +2.611 | aa11(?) | A16(?) | 2 | 41.6 | 0.1 | 50 | 440.9 | 440.927 | 0.0846579 | 0.000264129 | 2.07341
TREILLIS | +2.170 | +2.611 | aa16(?) | A16(?) | 2 | 41.6 | 0.1 | 50 | 440.9 | 440.869 | 0.0846469 | 0.000264096 | 2.07315
TREILLIS |  |  | A25 | A25 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0

# IfcElementAssembly (98)
In: Undefined
Name | Poids Assemblage/Elément béton (kg) | Niveau Bas Assemblage/Elément béton | Niveau Haut Assemblage/Elément béton | Position maillage Assemblage/Elément béton | Repère Assemblage/Elément béton | Width (mm)
POTEAU AV | 44.6 | +0.200 | +2.683 | 3/A | A29(?) | 162.5
TREILLIS | 76.4 | +2.115 | +2.666 | 1-3/A | A16(?) | 136.435
2 x CVT | 8.8 | +0.358 | +2.066 | 2-3/B | A45(?) | 60
POTEAU AV | 36.3 | +0.200 | +2.170 | 2/B | A32(?) | 185
POTEAU AV | 35.9 | +0.200 | +2.170 | 3/B | A5(?) | 162.5
CVT | 9.1 | +2.082 | +2.355 | 1-2/A-B | A35(?) | 60
GOUSSET_ENROULE2 | 2.8 | +2.325 | +2.419 | 2/A-B | A41(?) | 102
POTEAU AV | 44.5 | +0.200 | +2.700 | 1/A | A30(?) | 162.5
CVT | 9.1 | +2.324 | +2.589 | 2-3/A-B | A38(?) | 60
GOUSSET_ENROULE4 | 2.8 | +2.512 | +2.651 | 3/A | A21(?) | 102
CAI-Att-FA | 0.4 | +2.586 | +2.661 | 2/A | A46(?) | 60
GOUSSET_ENROULE2 | 2.8 | +2.316 | +2.410 | 2/A-B | A9(?) | 102
CAI-Att-FA | 0.4 | +2.586 | +2.661 | 2/A | A48(?) | 60
2 x ECROU | 0 | +0.216 | +0.230 | 3/B | E3 | 28
2 x Washer Plate | 0.1 | +0.210 | +0.216 | 3/B | E2 | 6
2 x BARRE | 0.2 | +0.040 | +0.240 | 3/B | B1 | 14
2 x ECROU | 0 | +0.216 | +0.230 | 3/A | E3 | 28
2 x Washer Plate | 0.1 | +0.210 | +0.216 | 3/A | E2 | 6
2 x BARRE | 0.2 | +0.040 | +0.240 | 3/A | B1 | 14
2 x ECROU | 0 | +0.216 | +0.230 | 2/B | E3 | 28
2 x Washer Plate | 0.1 | +0.210 | +0.216 | 2/B | E2 | 6
2 x BARRE | 0.2 | +0.040 | +0.240 | 2/B | B1 | 14
2 x ECROU | 0 | +0.216 | +0.230 | 1/B | E3 | 28
Washer Plate | 0.1 | +0.210 | +0.216 | 1/B | E2 | 6
2 x BARRE | 0.2 | +0.040 | +0.240 | 1/B | B1 | 14
Poteau AR | 35.6 | +0.200 | +2.170 | 1/B | A7(?) | 162.5
2 x ECROU | 0 | +0.216 | +0.230 | 1/A | E3 | 28
2 x Washer Plate | 0.1 | +0.210 | +0.216 | 1/A | E2 | 6
2 x BARRE | 0.2 | +0.040 | +0.240 | 1/A | B1 | 14
POTEAU | 30 | +0.000 | +0.200 | 3/B | Pt1 | 250 | Tekla Assemblages - Cast unit type: Coulé sur site; Poids ferraillage Elément béton: 0 kg
POTEAU | 30 | +0.000 | +0.200 | 2/B | Pt1 | 250 | Tekla Assemblages - Cast unit type: Coulé sur site; Poids ferraillage Elément béton: 0 kg
POTEAU | 30 | +0.000 | +0.200 | 1/B | Pt1 | 250 | Tekla Assemblages - Cast unit type: Coulé sur site; Poids ferraillage Elément béton: 0 kg
POTEAU | 30 | +0.000 | +0.200 | 1/A | Pt1 | 250 | Tekla Assemblages - Cast unit type: Coulé sur site; Poids ferraillage Elément béton: 0 kg
POTEAU | 30 | +0.000 | +0.200 | 3/A | Pt1 | 250 | Tekla Assemblages - Cast unit type: Coulé sur site; Poids ferraillage Elément béton: 0 kg
CVT | 12.6 | +1.988 | +2.130 | 2-3/B | A1(?) | 142.004
CVT | 9.1 | +2.081 | +2.355 | 2-3/A-B | A40(?) | 60
CORNIERE | 0.4 | +2.095 | +2.169 | 3/B | 3 | 45
CORNIERE | 0.4 | +2.138 | +2.183 | 3/B | 4 | 45
TOLE | 2 | +2.131 | +2.175 | 3/B | E1(?) | 6
ARBA | 48.5 | +1.868 | +2.686 | 2/A-B | A6(?) | 112.503
GOUSSET_ENROULE2 | 2.8 | +2.325 | +2.419 | 2/A-B | A11(?) | 102
GOUSSET_ENROULE2 | 2.8 | +2.278 | +2.418 | 2/A-B | A9(?) | 102
ARBA | 52.5 | +1.868 | +2.681 | 3/A-B | A24 | 98
C_JORIS100 | 8.4 | +2.554 | +2.661 | 1-2/A | A26 | 50
C_JORIS100 | 8.4 | +2.087 | +2.195 | 2-3/B | A22(?) | 50
C_JORIS100 | 8.4 | +2.554 | +2.661 | 2-3/A | A49(?) | 50
C_JORIS100 | 8.4 | +2.321 | +2.428 | 2-3/A-B | A13 | 50
C_JORIS100 | 8.4 | +2.321 | +2.428 | 1-2/A-B | A31(?) | 50
CVT | 9.1 | +2.324 | +2.589 | 1-2/A-B | A35(?) | 60
GOUSSET_ENROULE1 | 2.8 | +2.511 | +2.651 | 1/A | A19(?) | 102
LISSES | 14 | +1.680 | +1.720 | 1/A-B | A44 | 40
LISSES | 14 | +0.380 | +0.420 | 1/A-B | A44 | 40
Support-Lisse | 0.6 | +0.310 | +0.380 | 1/B | A36 | 70
Support-Lisse | 0.6 | +1.610 | +1.680 | 1/B | A36(?) | 70
Support-Lisse | 0.6 | +0.310 | +0.380 | 1/A | A37 | 70
Support-Lisse | 0.6 | +1.610 | +1.680 | 1/A | A37(?) | 70
Support-Lisse | 0.6 | +0.310 | +0.380 | 3/A | A36 | 70
Support-Lisse | 0.6 | +1.610 | +1.680 | 3/A | A36(?) | 70
Support-Lisse | 0.6 | +0.310 | +0.380 | 3/B | A37 | 70
Support-Lisse | 0.6 | +1.610 | +1.680 | 3/B | A37(?) | 70
LISSES | 14 | +0.380 | +0.420 | 3/A-B | A18 | 40
LISSES | 14 | +1.680 | +1.720 | 3/A-B | A18 | 40
Support-Lisse | 0.6 | +0.310 | +0.380 | 3/B | A43 | 70
Support-Lisse | 0.6 | +1.610 | +1.680 | 3/B | A34(?) | 70
CVT | 10.5 | +2.070 | +2.130 | 1-2/B | A2 | 60
C_JORIS100 | 8.4 | +2.087 | +2.195 | 1-2/B | A33 | 50
GOUSSET | 0.6 | +2.085 | +2.181 | 2/B | A39 | 71
2 x GOUSSET | 0.6 | +2.551 | +2.648 | 2/A | A39 | 71
GOUSSET | 0.6 | +2.085 | +2.181 | 2/B | A0(?) | 71
GOUSSET | 0.6 | +2.318 | +2.414 | 3/A-B | A39 | 71
ARBA | 46.3 | +1.868 | +2.683 | 1/A-B | A20(?) | 98
GOUSSET | 0.6 | +2.318 | +2.414 | 1/A-B | A39 | 71
TREILLIS | 0 |  |  |  | A25 | 0
LISSES | 12.4 | +0.380 | +0.420 | 2-3/B | A3 | 40
Support-Lisse | 0.6 | +0.310 | +0.380 | 2/B | 1(?) | 70
LISSES | 12.4 | +0.380 | +0.420 | 1-2/B | A28 | 40
Support-Lisse | 0.6 | +0.310 | +0.380 | 1/B | 2(?) | 70
LISSES | 12.4 | +1.680 | +1.720 | 1-2/B | A28 | 40
Support-Lisse | 0.6 | +1.610 | +1.680 | 1/B | 2 | 70
LISSES | 12.4 | +1.680 | +1.720 | 2-3/B | A3 | 40
Support-Lisse | 0.6 | +1.610 | +1.680 | 2/B | 1 | 70
GOUSSET_ENROULE2 | 2.8 | +2.092 | +2.186 | 1/B | A8(?) | 102

# IfcFastener (53)
In: Undefined
Tekla Soudure Commun - Niveau d'inspection NDT: Aucun; Coefficient de l'électrode: 0; Longueur de l'électrode: 0; Classification de l'électrode: Aucun; Type de procédé de soudage: Aucun; N° soudure: 0; Type d'assemblage: ATELIER; Type de cordon: Continu
Tekla Soudure dessus - Nombre d'incrément1: 0; Pas1: 0; Finition1: Aucun; Contour1: Aucun; Talon1: 0 mm; Ouverture racine1: 0 mm; Angle1: 0; Gorge effective1: 0 mm; Type1: W10
Tekla Soudure dessous - Longueur réelle2: 0 mm; Surface section2: 0 m2; Nombre d'incrément2: 0; Pas2: 0; Longueur2: 0 mm; Finition2: Aucun; Contour2: Aucun; Talon2: 0 mm; Ouverture racine2: 0 mm; Angle2: 0; Gorge effective2: 0 mm; Dimension2: 0 mm; Type2: Aucun
Name | Volume (m3) | Longueur (mm) = Logueur réelle1 (mm) | Linéaire/Périphérique | Surface section1 (m2) | Longueur1 (mm) | Dimension1 (mm)
8 x Weld | 0 | 70 | Autour | 0.00001 | 0 | 3
4 x Weld | 0 | 160.003 | Autour | 0.00001 | 0 | 3
8 x Weld | 0 | 40 | Autour | 0.00001 | 0 | 3
2 x Weld | 0 | 148.707 | Autour | 0.00001 | 0 | 3
4 x Weld | 0 | 120 | Autour | 0.00001 | 0 | 3
2 x Weld | 0 | 63 | Autour | 0.00001 | 0 | 3
2 x Weld | 0 | 67 | Autour | 0.00001 | 0 | 3
4 x Weld | 0 | 95.9442 | Autour | 0.00001 | 0 | 3
4 x Weld | 0.00001 | 206 | Autour | 0.00003 | 206 | 5
4 x Weld | 0.00001 | 206 | Autour | 0.00003 | 0 | 5
Weld | 0 | 206 | Autour | 0.00001 | 0 | 3
4 x Weld | 0.00001 | 243.719 | Droit | 0.00003 | 0 | 6
4 x Weld | 0 | 40 | Autour | 0.00003 | 0 | 6
2 x Weld | 0.00001 | 160 | Autour | 0.00003 | 0 | 6

# IfcMechanicalFastener: Bolt assembly (109)
In: Undefined
Tekla Boulons - Trou oblong Y: 0 mm; Trou oblong X: 0 mm
Name | NominalDiameter (mm) = Diamètre rondelle (mm) | NominalLength (mm) = Longueur (mm) | Material = Standard | Quantité de rondelle | Type rondelle | Nom rondelle | Quantité d'écrou | Type écrou | Nom écrou | Diamètre du trou (mm) | Lieu Boulonnage | Quantité | Diamètre (mm) | Nom
9 x Bolt assembly | 12 | 30 | SB8.8 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 1 | E-SB8.8 | ECROU-M12-E-SB8.8 | 14 | Montage | 1 | 12 | M12*30
3 x Bolt assembly | 12 | 30 | 8.8 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 1 | E-8.8 | ECROU-M12-E-8.8 | 14 | Montage | 1 | 12 | M12*30
2 x Bolt assembly | 12 | 80 | 8.8 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 1 | E-8.8 | ECROU-M12-E-8.8 | 14 | Montage | 1 | 12 | M12*80
13 x Bolt assembly | 12 | 25 | 8.8 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 1 | E-8.8 | ECROU-M12-E-8.8 | 14 | Montage | 1 | 12 | M12*25
13 x Bolt assembly | 12 | 25 | 8.8 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 3 | E-8.8 | ECROU-M12-E-8.8 | 14 | Montage | 3 | 12 | M12*25
19 x Bolt assembly | 12 | 25 | 8.8 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 2 | E-8.8 | ECROU-M12-E-8.8 | 14 | Montage | 2 | 12 | M12*25
3 x Bolt assembly | 12 | 35 | 8.8 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 2 | E-8.8 | ECROU-M12-E-8.8 | 14 | Montage | 2 | 12 | M12*35
10 x Bolt assembly | 14 | 6 | 6.8 | 0 | PLA-6.8 | RONDELLE-M14-PLA-6.8 | 0 | E-6.8 | ECROU-M14-E-6.8 | 17 | Montage | 1 | 17 | M14*30
2 x Bolt assembly | 12 | 30 | 8.8 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 3 | E-8.8 | ECROU-M12-E-8.8 | 14 | Montage | 3 | 12 | M12*30
4 x Bolt assembly | 12 | 50 | HR8.8 | 16 | PLA-HR8.8 | RONDELLE-M12-PLA-HR8.8 | 8 | E-HR8.8 | ECROU-M12-E-HR8.8 | 14 | Montage | 8 | 12 | M12*50
5 x Bolt assembly | 14 | 10 | 6.8 | 0 | PLA-6.8 | RONDELLE-M14-PLA-6.8 | 0 | E-6.8 | ECROU-M14-E-6.8 | 17 | Montage | 2 | 17 | M14*30
Bolt assembly | 12 | 25 | 8.8 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 1 | E-8.8 | ECROU-M12-E-8.8 | 14 | Atelier | 1 | 12 | M12*25
11 x Bolt assembly | 12 | 6 | 8.8 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 0 | E-8.8 | ECROU-M12-E-8.8 | 14 | Montage | 1 | 14 | M12*25
14 x Bolt assembly | 12 | 30 | 8.8 | 0 | PLA-8.8 | RONDELLE-M12-PLA-8.8 | 2 | E-8.8 | ECROU-M12-E-8.8 | 14 | Montage | 2 | 12 | M12*30

# IfcMember: IPE140 (3)
In: Undefined
Description: IPE140; Material: STEEL/S235JR
Tekla Commun - Niveau bas: +1.868; Niveau haut: +2.072; Phase: 1; Classe: 1; Matériau: S235JR; Profil: IPE140; Nom: JARRET
Tekla Quantités - Poids: 5.4 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 42.8 m2; Surface nette: 0.1 m2; Hauteur: 125.2 mm; Largeur: 73 mm; Longueur: 422.7 mm
Pset_MemberCommon - LoadBearing: no
BaseQuantities - Length: 422.732 mm; OuterSurfaceArea: 0.232925 m2; GrossSurfaceArea: 0.232925 m2; CrossSectionArea: 0.00164 m2; NetVolume: 0.000494731 m3; GrossVolume: 0.000693281 m3; NetWeight: 3.88364 kg; GrossWeight: 5.44225 kg
Name | Repère de pièce = Reference | Repère d'assemblage
JARRET | 17 | A6(?)
JARRET | 17 | A24
JARRET | 2 | A20(?)

# IfcMember: L60*4, CVT
In: Undefined
Description: L60*4; Material: STEEL/S235JR
Tekla Commun - Niveau bas: +2.216; Niveau haut: +2.463; Repère de pièce: aa7(?); Repère d'assemblage: A6(?); Finition: GALVA; Phase: 1; Classe: 3; Matériau: S235JR; Profil: L60*4; Nom: CVT
Tekla Quantités - Poids: 1.5 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 64 m2; Surface nette: 0.1 m2; Hauteur: 60 mm; Largeur: 60 mm; Longueur: 422.3 mm
Pset_MemberCommon - LoadBearing: no; Reference: aa7(?)
BaseQuantities - Length: 422.325 mm; OuterSurfaceArea: 0.0984016 m2; GrossSurfaceArea: 0.113735 m2; CrossSectionArea: 0.000471508 m2; NetVolume: 0.000195959 m3; GrossVolume: 0.000218094 m3; NetWeight: 1.53827 kg; GrossWeight: 1.71204 kg

# IfcMember: PL60*6 (2)
In: Undefined
Description: PL60*6; Material: STEEL/S235JR
Tekla Commun - Niveau bas: +0.358; Niveau haut: +0.470; Repère de pièce: aa0(?); Repère d'assemblage: A45(?); Finition: GALVA; Phase: 1; Classe: 6; Matériau: S235JR; Profil: PL60*6; Nom: CVT
Tekla Quantités - Poids: 0.4 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 49.1 m2; Surface nette: 0 m2; Hauteur: 60 mm; Largeur: 6 mm; Longueur: 101.8 mm
Pset_MemberCommon - LoadBearing: no; Reference: aa0(?)
BaseQuantities - Length: 101.823 mm; OuterSurfaceArea: 0.0137477 m2; GrossSurfaceArea: 0.0141606 m2; CrossSectionArea: 0.00036 m2; NetVolume: 0.0000356812 m3; GrossVolume: 0.0000366562 m3; NetWeight: 0.280097 kg; GrossWeight: 0.287751 kg

# IfcMember: TC-C50*50*3.2 (4)
In: Undefined
Description: TC-C50*50*3.2; Material: STEEL/S235JR
Tekla Commun - Niveau bas: +2.170; Niveau haut: +2.611; Repère d'assemblage: A16(?); Finition: GALVA; Phase: 1; Classe: 13; Matériau: S235JR; Profil: TC-C50*50*3.2; Nom: TREILLIS
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 41.6 m2; Surface nette: 0.2 m2; Hauteur: 50 mm; Largeur: 50 mm
Pset_MemberCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000588 m2
Name | Repère de pièce = Reference | Poids (kg) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) = GrossSurfaceArea (m2) | NetVolume (m3) | GrossVolume (m3) | NetWeight (kg) | GrossWeight (kg)
TREILLIS | aa24(?) | 5.6 | 1210.4 | 1210.38 | 0.232393 | 0.000675765 | 0.000711703 | 5.30476 | 5.58687
TREILLIS | aa10(?) | 5.6 | 1210.2 | 1210.22 | 0.232362 | 0.000675524 | 0.000711609 | 5.30286 | 5.58613
TREILLIS | aa17(?) | 5.9 | 1278 | 1277.99 | 0.245374 | 0.000705722 | 0.000751457 | 5.53992 | 5.89894
TREILLIS | aa12(?) | 5.9 | 1278 | 1277.87 | 0.245351 | 0.000705736 | 0.000751388 | 5.54003 | 5.89839

# IfcMember: TUBE-C-50*50*3 (2)
In: Undefined
Description: TUBE-C-50*50*3; Material: STEEL/S235JR
Tekla Commun - Niveau bas: +0.406; Niveau haut: +2.066; Repère de pièce: aa49(?); Repère d'assemblage: A45(?); Finition: GALVA; Phase: 1; Classe: 3; Matériau: S235JR; Profil: TUBE-C-50*50*3; Nom: CVT
Tekla Quantités - Poids: 8.5 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 44.5 m2; Surface nette: 0.4 m2; Hauteur: 50 mm; Largeur: 50 mm; Longueur: 2000 mm
Pset_MemberCommon - LoadBearing: no; Reference: aa49(?)
BaseQuantities - Length: 1999.97 mm; OuterSurfaceArea: 0.377995 m2; GrossSurfaceArea: 0.377995 m2; CrossSectionArea: 0.000541 m2; NetVolume: 0.00112624 m3; GrossVolume: 0.00108199 m3; NetWeight: 8.841 kg; GrossWeight: 8.49359 kg

# IfcPlate: PL 100*6 (3)
In: Undefined
Description: PL 100*6; Material: STEEL/S235JR
Tekla Commun - Niveau bas: +2.566; Niveau haut: +2.666; Repère de pièce: 13(?); Repère d'assemblage: A16(?); Finition: GALVA; Phase: 1; Classe: 2; Matériau: S235JR; Profil: PL 100*6; Nom: TREILLIS
Tekla Quantités - Poids: 0.6 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0 m2; Hauteur: 100 mm; Largeur: 6 mm
Pset_PlateCommon - Support de charge: no; Réference: 13(?)
BaseQuantities - Width: 100 mm; CrossSectionArea: 0.0006 m2
Name | Surface par tonne (m2) | Longueur (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
2 x TREILLIS | 47.1 | 149.9 | 0.0279847 | 0.0329882 | 0.0000756835 | 0.0000899665
TREILLIS | 46.7 | 154 | 0.033848 | 0.033848 | 0.0000924 | 0.0000924

# IfcPlate: PL 60*6 (6)
In: Undefined
Description: PL 60*6; Material: STEEL/S235JR
Pset_PlateCommon - Support de charge: no
Tekla Commun - Finition: GALVA; Phase: 1; Classe: 2; Matériau: S235JR; Profil: PL 60*6; Nom: TREILLIS
Tekla Quantités - Poids: 0.4 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 48.8 m2; Surface nette: 0 m2; Hauteur: 60 mm; Largeur: 6 mm; Longueur: 124 mm
BaseQuantities - Width: 60 mm; NetArea: 0.017088 m2; GrossArea: 0.017088 m2; CrossSectionArea: 0.00036 m2; NetVolume: 0.00004464 m3; GrossVolume: 0.00004464 m3
Name | Réference = Repère de pièce | Niveau bas | Niveau haut | Repère d'assemblage
TREILLIS | 0(?) | +2.115 | +2.175 | A16(?)
2 x TREILLIS | 13 | +2.070 | +2.130 | A1(?)
TREILLIS | aa58(?) | +2.115 | +2.175 | A16(?)
2 x TREILLIS | 13 | +2.070 | +2.130 | A2

# IfcPlate: PL 90*6 (9)
In: Undefined
Description: PL 90*6; Material: STEEL/S235JR
Tekla Commun - Finition: GALVA; Phase: 1; Classe: 6; Matériau: S235JR; Profil: PL 90*6; Nom: SUPPORT V TREILLIS
Tekla Quantités - Poids: 0.4 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0 m2; Hauteur: 90 mm; Largeur: 6 mm; Longueur: 120 mm
Pset_PlateCommon - Support de charge: no
BaseQuantities - Width: 90 mm; GrossArea: 0.02412 m2; CrossSectionArea: 0.00054 m2; GrossVolume: 0.0000648 m3
Name | Niveau bas | Niveau haut | Repère de pièce = Réference | Repère d'assemblage | Surface par tonne (m2) | NetArea (m2) | NetVolume (m3)
SUPPORT V TREILLIS | +2.055 | +2.175 | 0(?) | A29(?) | 47.7 | 0.0213962 | 0.00005715
SUPPORT V TREILLIS | +2.546 | +2.666 | 14(?) | A30(?) | 47.4 | 0.0236497 | 0.0000636
SUPPORT V TREILLIS | +2.546 | +2.666 | 14(?) | A29(?) | 47.4 | 0.0236497 | 0.0000636
SUPPORT V TREILLIS | +2.010 | +2.130 | 14 | A5(?) | 47.7 | 0.0213962 | 0.00005715
SUPPORT V TREILLIS | +2.546 | +2.666 | 14(?) | A30(?) | 47.7 | 0.0213962 | 0.00005715
SUPPORT V TREILLIS | +2.055 | +2.175 | aa57(?) | A30(?) | 47.7 | 0.0213962 | 0.00005715
SUPPORT V TREILLIS | +2.010 | +2.130 | 14 | A7(?) | 47.7 | 0.0213962 | 0.00005715
2 x SUPPORT V TREILLIS | +2.010 | +2.130 | 14 | A32(?) | 47.7 | 0.0213962 | 0.00005715

# IfcPlate: PL10*140 (5)
In: Undefined
Description: PL10*140; Material: STEEL/S235JR
Tekla Commun - Niveau bas: +0.200; Niveau haut: +0.210; Phase: 1; Classe: 99; Matériau: S235JR; Profil: PL10*140
Tekla Quantités - Poids: 1.5 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 29.1 m2; Surface nette: 0 m2; Hauteur: 140 mm; Largeur: 10 mm; Longueur: 140 mm
Pset_PlateCommon - Support de charge: no
BaseQuantities - Width: 140 mm; NetArea: 0.0448 m2; GrossArea: 0.0448 m2; CrossSectionArea: 0.0014 m2; NetVolume: 0.000196 m3; GrossVolume: 0.000196 m3
Name | Repère de pièce = Réference | Repère d'assemblage
Unnamed | 5(?) | A5(?)
Unnamed | 3 | A29(?)
Unnamed | 3(?) | A32(?)
Unnamed | 3(?) | A7(?)
Unnamed | 5(?) | A30(?)

# IfcPlate: PL10*40 (8)
In: Undefined
Description: PL10*40; Material: STEEL/S235JR
Tekla Commun - Phase: 1; Classe: 1; Matériau: S235JR; Profil: PL10*40; Nom: PLAT
Tekla Quantités - Poids: 0.2 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 34.9 m2; Surface nette: 0 m2; Hauteur: 40 mm; Largeur: 10 mm; Longueur: 80 mm
Pset_PlateCommon - Support de charge: no
BaseQuantities - Width: 40 mm; NetArea: 0.00837141 m2; GrossArea: 0.0032 m2; CrossSectionArea: 0.0001 m2; NetVolume: 0.00003056 m3; GrossVolume: 0.00003056 m3
Name | Niveau bas | Niveau haut | Repère de pièce = Réference | Repère d'assemblage
2 x PLAT | +1.859 | +1.869 | 19 | A32(?)
2 x PLAT | +1.859 | +1.869 | 19 | A5(?)
2 x PLAT | +2.404 | +2.414 | 4 | A29(?)
2 x PLAT | +1.859 | +1.869 | 4 | A7(?)

# IfcPlate: PL12*98 (4)
In: Undefined
Description: PL12*98; Material: STEEL/S235JR
Tekla Commun - Phase: 1; Classe: 1; Matériau: S235JR; Profil: PL12*98; Nom: PLAT
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 24.7 m2; Surface nette: 0.1 m2; Hauteur: 98 mm; Largeur: 12 mm
Pset_PlateCommon - Support de charge: no
BaseQuantities - Width: 98 mm; CrossSectionArea: 0.001176 m2
Name | Niveau bas | Niveau haut | Repère de pièce = Réference | Repère d'assemblage | Poids (kg) | Longueur (mm) | NetArea (m2) = GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLAT | +1.872 | +2.169 | 18 | A6(?) | 2.7 | 296.4 | 0.0675682 | 0.00034861
PLAT | +1.872 | +2.169 | 18 | A24 | 2.7 | 296.4 | 0.0675682 | 0.00034861
PLAT | +2.412 | +2.678 | 12 | A24 | 2.5 | 265.4 | 0.0607424 | 0.000312123
PLAT | +1.872 | +2.169 | 10 | A20(?) | 2.7 | 296.4 | 0.0675682 | 0.00034861

# IfcPlate: PL6*140 (2)
In: Undefined
Description: PL6*140; Material: STEEL/S235JR
Tekla Commun - Niveau bas: +1.988; Niveau haut: +2.128; Repère de pièce: aa38(?); Repère d'assemblage: A1(?); Phase: 1; Classe: 99; Matériau: S235JR; Profil: PL6*140; Nom: GOUSSET
Tekla Quantités - Poids: 1 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 45.8 m2; Surface nette: 0 m2; Hauteur: 140 mm; Largeur: 6 mm; Longueur: 170 mm
Pset_PlateCommon - Support de charge: no; Réference: aa38(?)
BaseQuantities - Width: 140.004 mm; NetArea: 0.0478878 m2; GrossArea: 0.0238007 m2; CrossSectionArea: 0.000036 m2; NetVolume: 0.000133317 m3; GrossVolume: 0.000142804 m3

# IfcPlate: PL6*250, TOLE
In: Undefined
Description: PL6*250; Material: STEEL/S235JR
Tekla Commun - Niveau bas: +2.131; Niveau haut: +2.175; Repère de pièce: E1(?); Repère d'assemblage: E1(?); Phase: 1; Classe: 6; Matériau: S235JR; Profil: PL6*250; Nom: TOLE
Tekla Quantités - Poids: 2 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 44.8 m2; Surface nette: 0.1 m2; Hauteur: 250.3 mm; Largeur: 6 mm; Longueur: 216 mm
Pset_PlateCommon - Support de charge: no; Réference: E1(?)
BaseQuantities - Width: 250.272 mm; NetArea: 0.0904767 m2; GrossArea: 0.0540587 m2; CrossSectionArea: 0.000036 m2; NetVolume: 0.000256992 m3; GrossVolume: 0.000256992 m3

# IfcPlate: PL6*50 (10)
In: Undefined
Description: PL6*50; Material: STEEL/S235JR
Tekla Commun - Niveau bas: +0.210; Niveau haut: +0.216; Phase: 1; Classe: 1; Matériau: S235JR; Profil: PL6*50; Nom: Washer Plate
Tekla Quantités - Poids: 0.1 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 52.7 m2; Surface nette: 0 m2; Hauteur: 50 mm; Largeur: 6 mm; Longueur: 50 mm
Pset_PlateCommon - Support de charge: no
BaseQuantities - Width: 50 mm; NetArea: 0.0062 m2; GrossArea: 0.0025 m2; CrossSectionArea: 0.000036 m2; NetVolume: 0.000015 m3; GrossVolume: 0.000015 m3
Name | Repère de pièce = Réference | Repère d'assemblage
9 x Washer Plate | E2 | E2
Washer Plate | 29(?) | A7(?)

# IfcPlate: PL6*82, GOUSSET
In: Undefined
Description: PL6*82; Material: STEEL/S235JR
Tekla Commun - Niveau bas: +2.387; Niveau haut: +2.478; Repère de pièce: 15(?); Repère d'assemblage: A6(?); Phase: 1; Classe: 99; Matériau: S235JR; Profil: PL6*82; Nom: GOUSSET
Tekla Quantités - Poids: 0.4 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 49 m2; Surface nette: 0 m2; Hauteur: 82.1 mm; Largeur: 6 mm; Longueur: 167.8 mm
Pset_PlateCommon - Support de charge: no; Réference: 15(?)
BaseQuantities - Width: 82.1167 mm; NetArea: 0.0191804 m2; GrossArea: 0.0137781 m2; CrossSectionArea: 0.000036 m2; NetVolume: 0.0000498147 m3; GrossVolume: 0.0000740386 m3

# IfcPlate: PL7*86, GOUSSET
In: Undefined
Description: PL7*86; Material: STEEL/S235JR
Tekla Commun - Niveau bas: +2.196; Niveau haut: +2.296; Repère de pièce: aa8(?); Repère d'assemblage: A16(?); Phase: 1; Classe: 99; Matériau: S235JR; Profil: PL7*86; Nom: GOUSSET
Tekla Quantités - Poids: 0.4 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 43.2 m2; Surface nette: 0 m2; Hauteur: 86.4 mm; Largeur: 7 mm; Longueur: 99.6 mm
Pset_PlateCommon - Support de charge: no; Réference: aa8(?)
BaseQuantities - Width: 86.434 mm; NetArea: 0.0140017 m2; GrossArea: 0.00860473 m2; CrossSectionArea: 0.000049 m2; NetVolume: 0.0000412481 m3; GrossVolume: 0.000076475 m3

# IfcPlate: PL8*67 (2)
In: Undefined
Description: PL8*67; Material: STEEL/S235JR
Pset_PlateCommon - Support de charge: no; Réference: 0(?)
Tekla Commun - Niveau bas: +0.257; Niveau haut: +0.417; Repère de pièce: 0(?); Phase: 1; Classe: 99; Matériau: S235JR; Profil: PL8*67; Nom: GOUSSET
Tekla Quantités - Poids: 0.4 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 40 m2; Surface nette: 0 m2; Hauteur: 66.8 mm; Largeur: 8 mm; Longueur: 160 mm
BaseQuantities - Width: 66.7932 mm; NetArea: 0.0151439 m2; GrossArea: 0.0106869 m2; CrossSectionArea: 0.000064 m2; NetVolume: 0.0000482307 m3; GrossVolume: 0.00004842 m3
Name | Repère d'assemblage
GOUSSET | A32(?)
GOUSSET | A5(?)

# IfcPlate: PL8*90 (4)
In: Undefined
Description: PL8*90; Material: STEEL/S235JR
Tekla Commun - Phase: 1; Classe: 1; Matériau: S235JR; Profil: PL8*90; Nom: PLAT
Tekla Quantités - Poids: 0.4 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 37.6 m2; Surface nette: 0 m2; Hauteur: 90 mm; Largeur: 8 mm; Longueur: 88 mm
Pset_PlateCommon - Support de charge: no
BaseQuantities - Width: 90 mm; NetArea: 0.018688 m2; GrossArea: 0.018688 m2; CrossSectionArea: 0.00072 m2; NetVolume: 0.00006336 m3; GrossVolume: 0.00006336 m3
Name | Niveau bas | Niveau haut | Repère de pièce = Réference | Repère d'assemblage
PLAT | +2.162 | +2.170 | 16 | A32(?)
PLAT | +2.162 | +2.170 | 16 | A5(?)
PLAT | +2.675 | +2.683 | 8 | A29(?)
PLAT | +2.162 | +2.170 | 8 | A7(?)
